# Allegro board ECS H11H4-AD2 v1.1 boardview.brd (continued)
## Nets (continued)
HDD_LED_P: F_PANEL.1 R764.2
HDMI0_CLK_N3: C63.2 CHOKE4.4 R62.1 RN2.7(A)
HDMI0_CLK_N3_R: CHOKE4.3 HDMI2.12 RN2.8(B) U4.5 U4.6
HDMI0_CLK_P3: C62.2 CHOKE4.1 R61.1 RN2.5(A)
HDMI0_CLK_P3_R: CHOKE4.2 HDMI2.10 RN2.6(B) U4.4 U4.7
HDMI0_CTRLCLK: C86.1 PCH1.BA5 QN1.2 R28.2
HDMI0_CTRLDATA: C77.1 PCH1.BC4 QN2.2 R35.2
HDMI0_HPD: PCH1.AW4 QN4.2 R86.2
HDMI0_HPD_CNN: C16.1 HDMI2.19 QN4.3 R30.1 U8.3
HDMI0_SCL: C12.1 HDMI2.15 QN1.3 R27.2 U8.4
HDMI0_SDA: C31.1 HDMI2.16 QN2.3 R41.2 U8.1
HDMI0_TX_N0: C61.2 CHOKE3.4 R60.1 RN2.3(A)
HDMI0_TX_N0_R: CHOKE3.3 HDMI2.9 RN2.4(B) U4.2 U4.9
HDMI0_TX_N1: C59.2 CHOKE2.4 R58.1 RN1.7(A)
HDMI0_TX_N1_R: CHOKE2.3 HDMI2.6 RN1.8(B) U3.5 U3.6
HDMI0_TX_N2: C57.2 CHOKE1.4 R56.1 RN1.3(A)
HDMI0_TX_N2_R: CHOKE1.3 HDMI2.3 RN1.4(B) U3.2 U3.9
HDMI0_TX_P0: C60.2 CHOKE3.1 R59.1 RN2.1(A)
HDMI0_TX_P0_R: CHOKE3.2 HDMI2.7 RN2.2(B) U4.1 U4.10
HDMI0_TX_P1: C58.2 CHOKE2.1 R57.1 RN1.5(A)
HDMI0_TX_P1_R: CHOKE2.2 HDMI2.4 RN1.6(B) U3.4 U3.7
HDMI0_TX_P2: C56.2 CHOKE1.1 R51.1 RN1.1(A)
HDMI0_TX_P2_R: CHOKE1.2 HDMI2.1 RN1.2(B) U3.1 U3.10
HDMI0SCL_VCC: D2.2 R27.1
HDMI0SDA_VCC: D2.1 R41.1
HDMI_CLK_N3: C83.2 CHOKE8.4 R85.1 RN4.7(A)
HDMI_CLK_N3_R: CHOKE8.3 HDMI1.12 RN4.8(B) U9.5 U9.6
HDMI_CLK_P3: C82.2 CHOKE8.1 R84.1 RN4.5(A)
HDMI_CLK_P3_R: CHOKE8.2 HDMI1.10 RN4.6(B) U9.4 U9.7
HDMI_CTRLCLK: C95.1 PCH1.BB3 QN7.2 R64.2
HDMI_CTRLDATA: C87.1 PCH1.BD6 QN8.2 R65.2
HDMI_HPD: PCH1.AY2 QN6.2 R103.2
HDMI_HPD_CNN: C42.1 HDMI1.19 QN6.3 R63.1 U11.3
HDMI_SCL: C46.1 HDMI1.15 QN7.3 R68.2 U11.4
HDMI_SDA: C47.1 HDMI1.16 QN8.3 R69.2 U11.1
HDMI_TX_N0: C81.2 CHOKE7.4 R83.1 RN4.3(A)
HDMI_TX_N0_R: CHOKE7.3 HDMI1.9 RN4.4(B) U9.2 U9.9
HDMI_TX_N1: C79.2 CHOKE6.4 R81.1 RN3.7(A)
HDMI_TX_N1_R: CHOKE6.3 HDMI1.6 RN3.8(B) U10.5 U10.6
HDMI_TX_N2: C76.2 CHOKE5.4 R79.1 RN3.3(A)
HDMI_TX_N2_R: CHOKE5.3 HDMI1.3 RN3.4(B) U10.2 U10.9
HDMI_TX_P0: C80.2 CHOKE7.1 R82.1 RN4.1(A)
HDMI_TX_P0_R: CHOKE7.2 HDMI1.7 RN4.2(B) U9.1 U9.10
HDMI_TX_P1: C78.2 CHOKE6.1 R80.1 RN3.5(A)
HDMI_TX_P1_R: CHOKE6.2 HDMI1.4 RN3.6(B) U10.4 U10.7
HDMI_TX_P2: C75.2 CHOKE5.1 R78.1 RN3.1(A)
HDMI_TX_P2_R: CHOKE5.2 HDMI1.1 RN3.2(B) U10.1 U10.10
HDMISCL_VCC: D4.2 R68.1
HDMISDA_VCC: D4.1 R69.1
HDPANEL_DETECT: C154.2 D13.3 F_AUDIO.4 PCH1.R36 R459.1
HM_5VDUAL: C573.1 R581.1 R582.2 U38.48
HM_12V: C566.1 R562.2 R563.1 U38.50
HM_VCC: C567.1 R564.2 R568.1 U38.49
HM_VCORE: C564.1 R560.2 U38.52
HM_VDIMM: C565.1 R561.2 U38.51
HSODN5: C238.2 PCIE1X.B15
HSODP5: C236.2 PCIE1X.B14
I2CLK: R176.1 U19.42
I2DATA: R177.1 U19.43
ISEN1_A: C70.2 R72.1 R90.2 R113.2 R162.2 U19.17
ISEN1_B: C167.2 R179.2 R188.1 R190.2 U19.51
ISEN2_A: C74.2 R48.2 R96.2 R98.2 R148.2 U19.16
ISEN2_B: C168.2 R180.2 R187.2 R191.1 U19.52
ISEN3_A: C109.2 R47.2 R99.1 R128.2 R146.2 U19.15
ISEN3_B: R173.1 U19.1
ISEN4_A: R112.1 U19.14
ISL95858_VIN: C158.2 R181.1 U19.44
ISOLATEB: R226.1 R232.1 U21.20
ITP_PMODE: PCH1.AT2 TP15.1
JDREF: CODEC.40 R106.2
JP1: R699.1 R700.1 U38.24
JP2: R559.1 R576.1 U38.56
JP3: R558.1 R575.1 U38.58
JP4: R557.1 R574.1 U38.60
KBRST_L: R648.2 U38.21
KBRST_L_RC: C594.1 PCH1.AT17 R647.1 R648.1
KCLK: R646.1 U38.39
KDAT: R665.1 U38.38
LAN_LED0: R149.2 U21.27
LAN_LED1: R150.2 U21.26
LAN_LED2: Q38.B R126.2 U21.25
LAN_MOS: C228.2 QSW1.G R241.1
LAN_PWR_CTRL: D15.2 R701.1 U38.26
LAN_RST_L_R: BT1.3 C218.2 R225.1 U21.19
LAN_WAKE: PCH1.BD11 R623.1 R645.2
LAN_WAKE_L: R224.2 R233.1 R645.1 U21.21
LAN_XTAL1: R219.2 U21.28
LAN_XTAL2: C209.2 U21.29 X1.2
LED_BT: M2_1.16 R732.1
LED_BT_R: Q36.B R732.2
LED_WLAN: M2_1.6 R733.1
LED_WLAN_R: Q34.B R733.2
LGATE1_A: QCL1.G QCL2.G U19.28
LGATE1_B: QCGL1.G QCGL2.G U19.34
LGATE2_A: QCL3.G QCL4.G U19.33
LGATE2_B: QCGL3.G QCGL4.G U27.5
LGATE3_A: QCL5.G QCL6.G U24.5
LINE1_JD: AUDIO.33 R139.2
LINE1_L: L6.1 Q4.C1 R49.2 R107.1
LINE1_L1: C44.2 CODEC.23
LINE1_L2: C44.1 R49.1
LINE1_L_P: Q4.B1 R9.2
LINE1_LL: AUDIO.34 C68.1 D6.2 L6.2
LINE1_R: L4.1 Q4.C2 R39.2 R104.1
LINE1_R1: C27.2 CODEC.24
LINE1_R2: C27.1 R39.1
LINE1_R_P: Q4.B2 R4.2
LINE1_RR: AUDIO.31 C66.1 D6.1 L4.2
LINE2_JD: F_AUDIO.10 R31.1
LINE2_L: C199.2 D14.2 F_AUDIO.9 Q2.C1 R137.2 R228.1
LINE2_L1: CODEC.14 EC5.1
LINE2_L2: EC5.2 R137.1
LINE2_L_P: Q2.B1 R7.2
LINE2_R: C200.2 D14.1 F_AUDIO.5 Q2.C2 R77.2 R231.1
LINE2_R1: CODEC.15 EC3.1
LINE2_R2: EC3.2 R77.1
LINE2_R_P: Q2.B2 R2.2
LPC_24M: C619.2 LPC_DEBUG.1 R709.1 R721.2
LPC_FRAME_L: LPC_DEBUG.3 PCH1.BE16 U38.16
LPC_LAD0: LPC_DEBUG.11 PCH1.AT22 U38.17
LPC_LAD1: LPC_DEBUG.10 PCH1.AV22 U38.18
LPC_LAD2: LPC_DEBUG.8 PCH1.AT19 U38.19
LPC_LAD3: LPC_DEBUG.7 PCH1.BD16 U38.20
LPC_PIRQ_L: PCH1.AW17 R671.1
LPC_PME_L: PCH1.W44 R445.1 R698.1 U38.32
LPCPD_L: PCH1.BC18 R715.2
LRST_L: C608.1 R681.2 U38.14
M.2_BTWIFI_SUS_CLK: M2_1.50 R540.2 R553.2 SC41.1
M.2_DIS_L_R: PCH1.BD27 R371.1
M.2_RST_L_RC: BT2.3 C396.1 M2_1.52 R366.1 R367.1
M.2_SMBCLK: M2_1.60 SC37.2 SR15.2
M.2_SMBDATA: M2_1.58 SC38.2 SR16.2
M.2_SSD_RST: M2_2.50 SC64.1 SR35.2
M.2_SSD_SUS_CLK: M2_2.68 R539.2 R552.2 SC62.1
M_BS_A0: CPU1.AY13 DIMM2.71
M_BS_A1: CPU1.AV15 DIMM2.190
M_BS_A2: CPU1.AW23 DIMM2.52
M_BS_B0: CPU1.AL18 DIMM1.71
M_BS_B1: CPU1.AM18 DIMM1.190
M_BS_B2: CPU1.AW28 DIMM1.52
M_CAS_A_L: CPU1.AY11 DIMM2.74
M_CAS_B_L: CPU1.AP16 DIMM1.74
M_CKE_A0: CPU1.AY24 DIMM2.50
M_CKE_A1: CPU1.AW24 DIMM2.169
M_CKE_B0: CPU1.AY29 DIMM1.50
M_CKE_B1: CPU1.AV29 DIMM1.169
M_CLK_A_N0: CPU1.AV18 DIMM2.185
M_CLK_A_N1: CPU1.AY17 DIMM2.64
M_CLK_A_P0: CPU1.AW18 DIMM2.184
M_CLK_A_P1: CPU1.AW17 DIMM2.63
M_CLK_B_N0: CPU1.AM21 DIMM1.185
M_CLK_B_N1: CPU1.AP21 DIMM1.64
M_CLK_B_P0: CPU1.AM20 DIMM1.184
M_CLK_B_P1: CPU1.AP22 DIMM1.63
M_CS_A_L0: CPU1.AW12 DIMM2.193
M_CS_A_L1: CPU1.AU11 DIMM2.76
M_CS_B_L0: CPU1.AP17 DIMM1.193
M_CS_B_L1: CPU1.AN15 DIMM1.76
M_DATA_A0: CPU1.AE40 DIMM2.3
M_DATA_A1: CPU1.AE37 DIMM2.4
M_DATA_A2: CPU1.AG38 DIMM2.9
M_DATA_A3: CPU1.AG37 DIMM2.10
M_DATA_A4: CPU1.AE39 DIMM2.122
M_DATA_A5: CPU1.AE38 DIMM2.123
M_DATA_A6: CPU1.AG39 DIMM2.128
M_DATA_A7: CPU1.AG40 DIMM2.129
M_DATA_A8: CPU1.AJ39 DIMM2.12
M_DATA_A9: CPU1.AJ37 DIMM2.13
M_DATA_A10: CPU1.AL38 DIMM2.18
M_DATA_A11: CPU1.AL37 DIMM2.19
M_DATA_A12: CPU1.AJ40 DIMM2.131
M_DATA_A13: CPU1.AJ38 DIMM2.132
M_DATA_A14: CPU1.AL39 DIMM2.137
M_DATA_A15: CPU1.AL40 DIMM2.138
M_DATA_A16: CPU1.AN40 DIMM2.21
M_DATA_A17: CPU1.AN37 DIMM2.22
M_DATA_A18: CPU1.AR38 DIMM2.27
M_DATA_A19: CPU1.AR37 DIMM2.28
M_DATA_A20: CPU1.AN39 DIMM2.140
M_DATA_A21: CPU1.AN38 DIMM2.141
M_DATA_A22: CPU1.AR39 DIMM2.146
M_DATA_A23: CPU1.AR40 DIMM2.147
M_DATA_A24: CPU1.AV37 DIMM2.30
M_DATA_A25: CPU1.AW37 DIMM2.31
M_DATA_A26: CPU1.AU35 DIMM2.36
M_DATA_A27: CPU1.AV35 DIMM2.37
M_DATA_A28: CPU1.AU38 DIMM2.149
M_DATA_A29: CPU1.AU37 DIMM2.150
M_DATA_A30: CPU1.AT35 DIMM2.155
M_DATA_A31: CPU1.AW35 DIMM2.156
M_DATA_A32: CPU1.AY8 DIMM2.81
M_DATA_A33: CPU1.AU8 DIMM2.82
M_DATA_A34: CPU1.AV6 DIMM2.87
M_DATA_A35: CPU1.AU6 DIMM2.88
M_DATA_A36: CPU1.AW8 DIMM2.200
M_DATA_A37: CPU1.AV8 DIMM2.201
M_DATA_A38: CPU1.AY6 DIMM2.206
M_DATA_A39: CPU1.AW6 DIMM2.207
M_DATA_A40: CPU1.AV4 DIMM2.90
M_DATA_A41: CPU1.AV3 DIMM2.91
M_DATA_A42: CPU1.AT3 DIMM2.96
M_DATA_A43: CPU1.AT2 DIMM2.97
M_DATA_A44: CPU1.AY4 DIMM2.209
M_DATA_A45: CPU1.AW4 DIMM2.210
M_DATA_A46: CPU1.AT4 DIMM2.215
M_DATA_A47: CPU1.AT1 DIMM2.216
M_DATA_A48: CPU1.AP1 DIMM2.99
M_DATA_A49: CPU1.AP2 DIMM2.100
M_DATA_A50: CPU1.AM3 DIMM2.105
M_DATA_A51: CPU1.AM2 DIMM2.106
M_DATA_A52: CPU1.AP4 DIMM2.218
M_DATA_A53: CPU1.AP3 DIMM2.219
M_DATA_A54: CPU1.AM4 DIMM2.224
M_DATA_A55: CPU1.AM1 DIMM2.225
M_DATA_A56: CPU1.AK3 DIMM2.108
M_DATA_A57: CPU1.AK2 DIMM2.109
M_DATA_A58: CPU1.AH3 DIMM2.114
M_DATA_A59: CPU1.AH2 DIMM2.115
M_DATA_A60: CPU1.AK4 DIMM2.227
M_DATA_A61: CPU1.AK1 DIMM2.228
M_DATA_A62: CPU1.AH4 DIMM2.233
M_DATA_A63: CPU1.AH1 DIMM2.234
M_DATA_B0: CPU1.AE34 DIMM1.3
M_DATA_B1: CPU1.AE35 DIMM1.4
M_DATA_B2: CPU1.AH34 DIMM1.9
M_DATA_B3: CPU1.AH35 DIMM1.10
M_DATA_B4: CPU1.AD34 DIMM1.122
M_DATA_B5: CPU1.AD35 DIMM1.123
M_DATA_B6: CPU1.AG34 DIMM1.128
M_DATA_B7: CPU1.AG35 DIMM1.129
M_DATA_B8: CPU1.AL34 DIMM1.12
M_DATA_B9: CPU1.AL35 DIMM1.13
M_DATA_B10: CPU1.AK31 DIMM1.18
M_DATA_B11: CPU1.AL31 DIMM1.19
M_DATA_B12: CPU1.AK34 DIMM1.131
M_DATA_B13: CPU1.AK35 DIMM1.132
M_DATA_B14: CPU1.AK32 DIMM1.137
M_DATA_B15: CPU1.AL32 DIMM1.138
M_DATA_B16: CPU1.AP35 DIMM1.21
M_DATA_B17: CPU1.AN34 DIMM1.22
M_DATA_B18: CPU1.AN31 DIMM1.27
M_DATA_B19: CPU1.AP31 DIMM1.28
M_DATA_B20: CPU1.AN35 DIMM1.140
M_DATA_B21: CPU1.AP34 DIMM1.141
M_DATA_B22: CPU1.AN32 DIMM1.146
M_DATA_B23: CPU1.AP32 DIMM1.147
M_DATA_B24: CPU1.AM29 DIMM1.30
M_DATA_B25: CPU1.AM28 DIMM1.31
M_DATA_B26: CPU1.AR29 DIMM1.36
M_DATA_B27: CPU1.AR28 DIMM1.37
M_DATA_B28: CPU1.AL29 DIMM1.149
M_DATA_B29: CPU1.AL28 DIMM1.150
M_DATA_B30: CPU1.AP29 DIMM1.155
M_DATA_B31: CPU1.AP28 DIMM1.156
M_DATA_B32: CPU1.AR12 DIMM1.81
M_DATA_B33: CPU1.AP12 DIMM1.82
M_DATA_B34: CPU1.AL13 DIMM1.87
M_DATA_B35: CPU1.AL12 DIMM1.88
M_DATA_B36: CPU1.AR13 DIMM1.200
M_DATA_B37: CPU1.AP13 DIMM1.201
M_DATA_B38: CPU1.AM13 DIMM1.206
M_DATA_B39: CPU1.AM12 DIMM1.207
M_DATA_B40: CPU1.AP9 DIMM1.90
M_DATA_B41: CPU1.AR9 DIMM1.91
M_DATA_B42: CPU1.AP7 DIMM1.96
M_DATA_B43: CPU1.AP6 DIMM1.97
M_DATA_B44: CPU1.AP10 DIMM1.209
M_DATA_B45: CPU1.AR10 DIMM1.210
M_DATA_B46: CPU1.AR7 DIMM1.215
M_DATA_B47: CPU1.AR6 DIMM1.216
M_DATA_B48: CPU1.AM9 DIMM1.99
M_DATA_B49: CPU1.AL9 DIMM1.100
M_DATA_B50: CPU1.AL6 DIMM1.105
M_DATA_B51: CPU1.AL7 DIMM1.106
M_DATA_B52: CPU1.AM10 DIMM1.218
M_DATA_B53: CPU1.AL10 DIMM1.219
M_DATA_B54: CPU1.AM6 DIMM1.224
M_DATA_B55: CPU1.AM7 DIMM1.225
M_DATA_B56: CPU1.AJ7 DIMM1.108
M_DATA_B57: CPU1.AH6 DIMM1.109
M_DATA_B58: CPU1.AF7 DIMM1.114
M_DATA_B59: CPU1.AE7 DIMM1.115
M_DATA_B60: CPU1.AH7 DIMM1.227
M_DATA_B61: CPU1.AJ6 DIMM1.228
M_DATA_B62: CPU1.AF6 DIMM1.233
M_DATA_B63: CPU1.AE6 DIMM1.234
M_DQS_A_N0: CPU1.AF39 DIMM2.6
M_DQS_A_N1: CPU1.AK39 DIMM2.15
M_DQS_A_N2: CPU1.AP39 DIMM2.24
M_DQS_A_N3: CPU1.AU36 DIMM2.33
M_DQS_A_N4: CPU1.AW7 DIMM2.84
M_DQS_A_N5: CPU1.AU3 DIMM2.93
M_DQS_A_N6: CPU1.AN3 DIMM2.102
M_DQS_A_N7: CPU1.AJ3 DIMM2.111
M_DQS_A_P0: CPU1.AF38 DIMM2.7
M_DQS_A_P1: CPU1.AK38 DIMM2.16
M_DQS_A_P2: CPU1.AP38 DIMM2.25
M_DQS_A_P3: CPU1.AV36 DIMM2.34
M_DQS_A_P4: CPU1.AV7 DIMM2.85
M_DQS_A_P5: CPU1.AU2 DIMM2.94
M_DQS_A_P6: CPU1.AN2 DIMM2.103
M_DQS_A_P7: CPU1.AJ2 DIMM2.112
M_DQS_B_N0: CPU1.AF34 DIMM1.6
M_DQS_B_N1: CPU1.AK33 DIMM1.15
M_DQS_B_N2: CPU1.AN33 DIMM1.24
M_DQS_B_N3: CPU1.AN29 DIMM1.33
M_DQS_B_N4: CPU1.AN13 DIMM1.84
M_DQS_B_N5: CPU1.AR8 DIMM1.93
M_DQS_B_N6: CPU1.AM8 DIMM1.102
M_DQS_B_N7: CPU1.AG6 DIMM1.111
M_DQS_B_P0: CPU1.AF35 DIMM1.7
M_DQS_B_P1: CPU1.AL33 DIMM1.16
M_DQS_B_P2: CPU1.AP33 DIMM1.25
M_DQS_B_P3: CPU1.AN28 DIMM1.34
M_DQS_B_P4: CPU1.AN12 DIMM1.85
M_DQS_B_P5: CPU1.AP8 DIMM1.94
M_DQS_B_P6: CPU1.AL8 DIMM1.103
M_DQS_B_P7: CPU1.AG7 DIMM1.112
M_MA_A0: CPU1.AW15 DIMM2.188
M_MA_A1: CPU1.AU18 DIMM2.181
M_MA_A2: CPU1.AU17 DIMM2.61
M_MA_A3: CPU1.AV19 DIMM2.180
M_MA_A4: CPU1.AT19 DIMM2.59
M_MA_A5: CPU1.AU20 DIMM2.58
M_MA_A6: CPU1.AV20 DIMM2.178
M_MA_A7: CPU1.AU21 DIMM2.56
M_MA_A8: CPU1.AT20 DIMM2.177
M_MA_A9: CPU1.AT22 DIMM2.175
M_MA_A10: CPU1.AY14 DIMM2.70
M_MA_A11: CPU1.AU22 DIMM2.55
M_MA_A12: CPU1.AV22 DIMM2.174
M_MA_A13: CPU1.AV12 DIMM2.196
M_MA_A14: CPU1.AV23 DIMM2.172
M_MA_A15: CPU1.AU24 DIMM2.171
M_MA_B0: CPU1.AL19 DIMM1.188
M_MA_B1: CPU1.AL22 DIMM1.181
M_MA_B2: CPU1.AM22 DIMM1.61
M_MA_B3: CPU1.AM23 DIMM1.180
M_MA_B4: CPU1.AP23 DIMM1.59
M_MA_B5: CPU1.AL23 DIMM1.58
M_MA_B6: CPU1.AW26 DIMM1.178
M_MA_B7: CPU1.AY26 DIMM1.56
M_MA_B8: CPU1.AU26 DIMM1.177
M_MA_B9: CPU1.AW27 DIMM1.175
M_MA_B10: CPU1.AP18 DIMM1.70
M_MA_B11: CPU1.AU27 DIMM1.55
M_MA_B12: CPU1.AV27 DIMM1.174
M_MA_B13: CPU1.AR15 DIMM1.196
M_MA_B14: CPU1.AY28 DIMM1.172
M_MA_B15: CPU1.AU28 DIMM1.171
M_ODT_A0: CPU1.AW11 DIMM2.195
M_ODT_A1: CPU1.AU14 DIMM2.77
M_ODT_B0: CPU1.AM16 DIMM1.195
M_ODT_B1: CPU1.AL16 DIMM1.77
M_PARITY_A: CPU1.AY15 STP11.1
M_PARITY_B: CPU1.AL20 STP39.1
M_PEX1_RX_N10: M2_1.43 PCH1.G29
M_PEX1_RX_P10: M2_1.41 PCH1.E29
M_PEX1_TX_N10: C387.2 PCH1.C32
M_PEX1_TX_P10: C388.2 PCH1.B32
M_RAS_A_L: CPU1.AW13 DIMM2.192
M_RAS_B_L: CPU1.AN18 DIMM1.192
M_WE_A_L: CPU1.AV14 DIMM2.73
M_WE_B_L: CPU1.AL17 DIMM1.73
MCLK: R636.1 U38.41
MCUVDDH: SR2.1 U7.38
MDAT: R640.1 U38.40
MDI0_N: C140.1 U18.6 U21.2 USB2_LAN.P3
MDI0_P: C139.1 U18.1 U21.1 USB2_LAN.P2
MDI1_N: C142.1 U18.4 U21.5 USB2_LAN.P5
MDI1_P: C141.1 U18.3 U21.4 USB2_LAN.P4
MDI2_N: C144.1 U17.1 U21.7 USB2_LAN.P7
MDI2_P: C143.1 U17.6 U21.6 USB2_LAN.P6
MDI3_N: C146.1 U17.3 U21.10 USB2_LAN.P9
MDI3_P: C145.1 U17.4 U21.9 USB2_LAN.P8
MIC1_JD: AUDIO.13 R138.2
MIC1_L: L1.1 Q5.C1 R34.2 R38.1 R101.2
MIC1_L1: C69.2 CODEC.21
MIC1_L2: C69.1 R101.1
MIC1_L_P: Q5.B1 R10.2
MIC1_LL: AUDIO.14 C32.1 D3.2 L1.2
MIC1_R: L2.1 Q5.C2 R33.2 R43.1 R88.2
MIC1_R1: C54.2 CODEC.22
MIC1_R2: C54.1 R88.1
MIC1_R_P: Q5.B2 R5.2
MIC1_RR: AUDIO.11 C48.1 D3.1 L2.2
MIC1_VREFO-L: CODEC.28 R34.1
MIC1_VREFO-R: CODEC.32 R33.1
MIC2-VREFO: CODEC.30 D1.3
MIC2-VREFO_L: D1.2 R19.1
MIC2-VREFO_R: D1.1 R21.1
MIC2_JD: F_AUDIO.6 R32.1
MIC2_L: C138.2 D11.2 F_AUDIO.1 Q1.C1 R19.2 R119.2 R171.1
MIC2_L1: C96.1 CODEC.16
MIC2_L2: C96.2 R119.1
MIC2_L_P: Q1.B1 R6.2
MIC2_R: C124.2 D11.1 F_AUDIO.3 Q1.C2 R21.2 R108.2 R136.1
MIC2_R1: C84.1 CODEC.17
MIC2_R2: C84.2 R108.1
MIC2_R_P: Q1.B2 R1.2
MIN_LOAD_Q: QN39.1 QN40.3 R414.1
MPEX1_TX_N10: C387.1 M2_1.37
MPEX1_TX_P10: C388.1 M2_1.35
OPC_ZVM_L: CPU1.AC38 STP38.1
P95_BST: R514.1 U35.10
P95_BST_R: C534.1 R514.2
P95_CS: R513.2 U35.2
P95_FB: R492.1 R493.1 R500.2 U35.4
P95_FB_R: C523.2 C525.1 R485.2 R493.2
P95_FB_RC: C523.1 R492.2
P95_LG: R542.1 U35.6
P95_LG_R: QBL1.G R542.2
P95_PH: C534.2 L23.1 QBH1.S1 QBH1.S2 QBH1.S3 QBL1.D1 QBL1.D2 QBL1.D3 QBL1.D4 QBL1.D5 R473.2 R533.2 U35.8
P95_RF: R476.1 U35.5
P95_UG: R474.1 U35.9
P95_UG_R: QBH1.G R473.1 R474.2
P95_VDD: C517.1 R457.1 R512.1 U35.3 U35.7
PC_BEEP: CODEC.12 TP5.1
PCH_GPP_F22: PCH1.W39 R480.1 U23.2
PCH_INTRUDER_L: PCH1.BE11 R605.2
PCH_JTAG_TCK: PCH1.AN3 R532.1
PCH_JTAG_TDI: PCH1.AP2 R271.2 R541.2
PCH_JTAG_TDO: PCH1.AP1 R263.2 R528.2
PCH_JTAG_TMS: PCH1.AR2 R262.2 R566.2
PCH_JTAGX: PCH1.AR3 R268.2 R269.2
PCH_PECI: C530.1 PCH1.AL3 R270.2 R499.1
PCH_PLTRST_L: BT1.2 R609.2 R681.1
PCH_PWROK: C646.2 PCH1.AW11 QN34.1 R519.2 R712.2 R713.2
PCH_PWROK_R: QN24.1 R518.1 R519.1
PCH_SMI_L: PCH1.M45 R413.1
PCH_SPKR: PCH1.BD26 R628.1 R659.1 R705.1
PCH_SYSPWROK: C605.1 PCH1.AY1 Q18.C Q19.C QN13.3 R342.2 R346.2 R684.1 U38.36
PCH_THERMTRIP_L: PCH1.AJ3 R488.2
PCH_TRIGIN: PCH1.AK1 R498.1
PCH_TRIGIN_R: CPU1.B3 R498.2
PCH_TRIGOUT: CPU1.D1 R507.2
PCH_TRIGOUT_R: PCH1.AL2 R507.1
PCH_TRST_L: PCH1.AY5 SR22.1
PCH_XDP_CLK_N: PCH1.L1 TP10.1
PCH_XDP_CLK_P: PCH1.L2 TP9.1
PCH_XDP_PRDY_L: PCH1.AT4 R569.1
PCH_XDP_PREQ_L: PCH1.AT3 R583.1
PCIE_WAKE_L: PCH1.BC13 PCIE1X.B11 PCIE16X.B11 R354.2 R624.1 SR32.2
PCIE_WAKE_S: M2_2.54 SR32.1
PCIERCOMP_N: PCH1.B18 R408.1
PCIERCOMP_P: PCH1.C17 R408.2
PCIRST3_L: BT2.2 R246.2 R254.2 R367.2 R638.1 R708.2 SR35.1 U23.1 U38.42
PCUSTB0_N: CPU1.E14 STP9.1
PCUSTB0_P: CPU1.F14 STP8.1
PCUSTB1_N: CPU1.G18 STP3.1
PCUSTB1_P: CPU1.F18 STP6.1
PEG_RCOMP: CPU1.L7 R286.2
PEG_RX_N0: CPU1.B7 PCIE16X.A17
PEG_RX_N1: CPU1.C6 PCIE16X.A22
PEG_RX_N2: CPU1.D5 PCIE16X.A26
PEG_RX_N3: CPU1.E4 PCIE16X.A30
PEG_RX_N4: CPU1.F5 PCIE16X.A36
PEG_RX_N5: CPU1.G4 PCIE16X.A40
PEG_RX_N6: CPU1.H5 PCIE16X.A44
PEG_RX_N7: CPU1.J4 PCIE16X.A48
PEG_RX_N8: CPU1.K5 PCIE16X.A53
PEG_RX_N9: CPU1.L4 PCIE16X.A57
PEG_RX_N10: CPU1.M5 PCIE16X.A61
PEG_RX_N11: CPU1.N4 PCIE16X.A65
PEG_RX_N12: CPU1.P5 PCIE16X.A69
PEG_RX_N13: CPU1.R4 PCIE16X.A73
PEG_RX_N14: CPU1.T5 PCIE16X.A77
PEG_RX_N15: CPU1.U4 PCIE16X.A81
PEG_RX_P0: CPU1.B8 PCIE16X.A16
PEG_RX_P1: CPU1.C7 PCIE16X.A21
PEG_RX_P2: CPU1.D6 PCIE16X.A25
PEG_RX_P3: CPU1.E5 PCIE16X.A29
PEG_RX_P4: CPU1.F6 PCIE16X.A35
PEG_RX_P5: CPU1.G5 PCIE16X.A39
PEG_RX_P6: CPU1.H6 PCIE16X.A43
PEG_RX_P7: CPU1.J5 PCIE16X.A47
PEG_RX_P8: CPU1.K6 PCIE16X.A52
PEG_RX_P9: CPU1.L5 PCIE16X.A56
PEG_RX_P10: CPU1.M6 PCIE16X.A60
PEG_RX_P11: CPU1.N5 PCIE16X.A64
PEG_RX_P12: CPU1.P6 PCIE16X.A68
PEG_RX_P13: CPU1.R5 PCIE16X.A72
PEG_RX_P14: CPU1.T6 PCIE16X.A76
PEG_RX_P15: CPU1.U5 PCIE16X.A80
PEG_TX_C_N0: C235.2 PCIE16X.B15
PEG_TX_C_N1: C241.2 PCIE16X.B20
PEG_TX_C_N2: C245.2 PCIE16X.B24
PEG_TX_C_N3: C258.2 PCIE16X.B28
PEG_TX_C_N4: C260.2 PCIE16X.B34
PEG_TX_C_N5: C266.2 PCIE16X.B38
PEG_TX_C_N6: C274.2 PCIE16X.B42
PEG_TX_C_N7: C278.2 PCIE16X.B46
PEG_TX_C_N8: C291.2 PCIE16X.B51
PEG_TX_C_N9: C307.2 PCIE16X.B55
PEG_TX_C_N10: C332.2 PCIE16X.B59
PEG_TX_C_N11: C334.2 PCIE16X.B63
PEG_TX_C_N12: C342.2 PCIE16X.B67
PEG_TX_C_N13: C347.2 PCIE16X.B71
PEG_TX_C_N14: C351.2 PCIE16X.B75
PEG_TX_C_N15: C362.2 PCIE16X.B79
PEG_TX_C_P0: C237.2 PCIE16X.B14
PEG_TX_C_P1: C242.2 PCIE16X.B19
PEG_TX_C_P2: C255.2 PCIE16X.B23
PEG_TX_C_P3: C259.2 PCIE16X.B27
PEG_TX_C_P4: C262.2 PCIE16X.B33
PEG_TX_C_P5: C270.2 PCIE16X.B37
PEG_TX_C_P6: C275.2 PCIE16X.B41
PEG_TX_C_P7: C279.2 PCIE16X.B45
PEG_TX_C_P8: C297.2 PCIE16X.B50
PEG_TX_C_P9: C316.2 PCIE16X.B54
PEG_TX_C_P10: C333.2 PCIE16X.B58
PEG_TX_C_P11: C335.2 PCIE16X.B62
PEG_TX_C_P12: C343.2 PCIE16X.B66
PEG_TX_C_P13: C348.2 PCIE16X.B70
PEG_TX_C_P14: C354.2 PCIE16X.B74
PEG_TX_C_P15: C357.2 PCIE16X.B78
PEG_TX_N0: C235.1 CPU1.A6
PEG_TX_N1: C241.1 CPU1.B5
PEG_TX_N2: C245.1 CPU1.C4
PEG_TX_N3: C258.1 CPU1.D3
PEG_TX_N4: C260.1 CPU1.E2
PEG_TX_N5: C266.1 CPU1.F3
PEG_TX_N6: C274.1 CPU1.G2
PEG_TX_N7: C278.1 CPU1.H3
PEG_TX_N8: C291.1 CPU1.J2
PEG_TX_N9: C307.1 CPU1.K3
PEG_TX_N10: C332.1 CPU1.L2
PEG_TX_N11: C334.1 CPU1.M3
PEG_TX_N12: C342.1 CPU1.N2
PEG_TX_N13: C347.1 CPU1.P3
PEG_TX_N14: C351.1 CPU1.R1
PEG_TX_N15: C362.1 CPU1.T3
PEG_TX_P0: C237.1 CPU1.A5
PEG_TX_P1: C242.1 CPU1.B4
PEG_TX_P2: C255.1 CPU1.C3
PEG_TX_P3: C259.1 CPU1.D2
PEG_TX_P4: C262.1 CPU1.E1
PEG_TX_P5: C270.1 CPU1.F2
PEG_TX_P6: C275.1 CPU1.G1
PEG_TX_P7: C279.1 CPU1.H2
PEG_TX_P8: C297.1 CPU1.J1
PEG_TX_P9: C316.1 CPU1.K2
PEG_TX_P10: C333.1 CPU1.L1
PEG_TX_P11: C335.1 CPU1.M2
PEG_TX_P12: C343.1 CPU1.N1
PEG_TX_P13: C348.1 CPU1.P2
PEG_TX_P14: C354.1 CPU1.R2
PEG_TX_P15: C357.1 CPU1.T2
PEX1_100M_N: PCH1.D5 PCIE1X.A14
PEX1_100M_P: PCH1.E6 PCIE1X.A13
PEX1_RST_L2: C229.1 PCIE1X.A11 R246.1
PEX1_RX_N5: PCH1.K19 PCIE1X.A17
PEX1_RX_N7: PCH1.L22 R753.2
PEX1_RX_N7_S: M2_2.29 R753.1
PEX1_RX_N8: PCH1.K24 R747.2
PEX1_RX_P5: PCH1.L19 PCIE1X.A16
PEX1_RX_P7: PCH1.K22 R752.2
PEX1_RX_P7_S: M2_2.31 R752.1
PEX1_RX_P8: PCH1.L24 R746.1
PEX1_TX_N5: C238.1 PCH1.D22
PEX1_TX_N7: C633.2 PCH1.C23
PEX1_TX_N7_S: C633.1 M2_2.35
PEX1_TX_N8: PCH1.C24 SC68.1
PEX1_TX_P5: C236.1 PCH1.C22
PEX1_TX_P7: C632.2 PCH1.B23
PEX1_TX_P7_S: C632.1 M2_2.37
PEX1_TX_P8: PCH1.B24 SC67.1
PEX16_100M_N: PCH1.W10 PCIE16X.A14
PEX16_100M_P: PCH1.W11 PCIE16X.A13
PEX16_RST: R248.1 R253.1 R254.1 U23.4
PEX16_RST_L: C230.1 PCIE16X.A11 R248.2
PHASE1_A: C104.2 L13.1 QCH1.S1 QCH1.S2 QCH1.S3 QCL1.D1 QCL1.D2 QCL1.D3 QCL1.D4 QCL1.D5 QCL2.D1 QCL2.D2 QCL2.D3 QCL2.D4 QCL2.D5 R222.1 R239.2 SP1.1 U19.26
PHASE1_B: C137.2 L17.1 QCGH1.S1 QCGH1.S2 QCGH1.S3 QCGL1.D1 QCGL1.D2 QCGL1.D3 QCGL1.D4 QCGL1.D5 QCGL2.D1 QCGL2.D2 QCGL2.D3 QCGL2.D4 QCGL2.D5 R281.2 R290.1 SP8.1 U19.35
PHASE1A_R: R72.2 R73.2 SP1.2
PHASE1B_R: R188.2 R208.2 SP8.2
PHASE2_A: C125.2 L14.1 QCH2.S1 QCH2.S2 QCH2.S3 QCL3.D1 QCL3.D2 QCL3.D3 QCL3.D4 QCL3.D5 QCL4.D1 QCL4.D2 QCL4.D3 QCL4.D4 QCL4.D5 R223.1 R240.2 SP2.1 U19.30
PHASE2_B: C328.1 L18.1 QCGH2.S1 QCGH2.S2 QCGH2.S3 QCGL3.D1 QCGL3.D2 QCGL3.D3 QCGL3.D4 QCGL3.D5 QCGL4.D1 QCGL4.D2 QCGL4.D3 QCGL4.D4 QCGL4.D5 R298.2 R303.1 SP10.1 U27.8
PHASE2A_R: R148.1 R164.2 SP2.2
PHASE2B_R: R191.2 R212.2 SP10.2
PHASE3_A: C243.1 L16.1 QCH3.S1 QCH3.S2 QCH3.S3 QCL5.D1 QCL5.D2 QCL5.D3 QCL5.D4 QCL5.D5 QCL6.D1 QCL6.D2 QCL6.D3 QCL6.D4 QCL6.D5 R264.2 R277.1 SP6.1 U24.8
PHASE3A_R: R99.2 R115.2 SP6.2
PLTRST_R_N: PCH1.BB27 R609.1
PM_DOWN: PCH1.AH2 R273.1
PM_SYNC: PCH1.AJ4 R486.1
PME_L: PCH1.BD17 R625.1
POP: Q6.C R1.1 R2.1 R3.1 R4.1 R5.1 R6.1 R7.1 R8.1 R9.1 R10.1
PROC_SEL_L: CPU1.AB36 STP37.1
PROCHOT_L: CPU1.C39 SR13.2
PROCPWRGD: PCH1.AM3 R508.1
PWM2_B: U19.40 U27.3
PWM3_A: U19.38 U24.3
R_CLKREQB: R206.1 U21.12
R_REGOUT: L11.1 U21.24
RJ45_P19: C51.1 C55.2 USB2_LAN.P1
ROM_CS_L0: C642.1 R763.2 SPI_DEBUG.1 SPIROM1.1
RS_4P7V: SC645.1 SR765.2 SR766.1 SR767.1
RS_4P7V_R: SQ42.B SR767.2
RSET: R183.1 U21.31
RSMRST_L: C585.1 C589.1 PCH1.BA11 R622.1 R711.1 SQ43.C U38.43
RSMRST_Q: SQ42.C SQ43.B SR768.2
RSVD_AW2: CPU1.AW2 STP5.1
RSVD_B39: CPU1.B39 STP17.1
RSVD_C40: CPU1.C40 STP26.1
RSVD_J7: CPU1.J7 STP29.1
RSVD_J8: CPU1.J8 STP27.1
RSVD_J17: CPU1.J17 STP34.1
RSVD_J19: CPU1.J19 STP33.1
RSVD_K8: CPU1.K8 STP31.1
RSVD_K10: CPU1.K10 STP32.1
RSVD_L8: CPU1.L8 STP36.1
RSVD_L10: CPU1.L10 STP35.1
RSVD_V1: CPU1.AV1 STP10.1
RTCRST_L: C482.1 PCH1.BC10 R416.2
RTCX1_IN: C588.1 PCH1.BC9 R618.1 R641.1
RTCX1_IN_R: R618.2 Y1.1
RTCX2_OUT: C592.1 PCH1.BD10 R641.2 Y1.2
SA0_CHA: DIMM2.117 R365.1
SA0_CHB: DIMM1.117 R380.1
SA1_CHA: DIMM2.237 R381.1
SA1_CHB: DIMM1.237 R379.1
SATA3_RX_N0: PCH1.G35 SC65.2
SATA3_RX_N2: C465.2 PCH1.F41
SATA3_RX_N3: C473.2 PCH1.D43
SATA3_RX_P0: PCH1.E35 SC66.2
SATA3_RX_P2: C453.2 PCH1.E41
SATA3_RX_P3: C481.2 PCH1.E42
SATA3_TX_N0: C631.2 PCH1.C36
SATA3_TX_N2: C475.2 PCH1.B39
SATA3_TX_N3: C462.2 PCH1.A41
SATA3_TX_P0: C630.2 PCH1.B36
SATA3_TX_P2: C485.2 PCH1.A39
SATA3_TX_P3: C452.2 PCH1.A40
SATA3R_N2: C465.1 SATA1.5
SATA3R_N3: C473.1 SATA2.5
SATA3R_P2: C453.1 SATA1.6
SATA3R_P3: C481.1 SATA2.6
SATA3T_N2: C475.1 SATA1.3
SATA3T_N3: C462.1 SATA2.3
SATA3T_P2: C485.1 SATA1.2
SATA3T_P3: C452.1 SATA2.2
SATA_PCIE_RXN_S: M2_2.41 R747.1 SC66.1
SATA_PCIE_RXP_S: M2_2.43 R746.2 SC65.1
SATA_PCIE_TXN_S: C631.1 M2_2.47 SC68.2
SATA_PCIE_TXP_S: C630.1 M2_2.49 SC67.2
SATALED_L: PCH1.AD44 Q37.E R543.1 R744.1
SDI: CODEC.8 R152.2
SENSE-A: CODEC.13 R138.1 R139.1 R140.1
SENSE-B: CODEC.34 R31.2 R32.2
SERIRQ: LPC_DEBUG.16 PCH1.BA17 R683.1 U38.15
SIO_24M: C613.1 R662.2 U38.23
SIO_BEEP: C614.1 R573.1 R720.2 U38.61
SIO_CLKIN: C611.1 R722.2 U38.25
SIO_GND: C564.2 C565.2 C566.2 C567.2 C573.2 C575.1 C580.1 C581.2 L24.2 R563.2 R568.2 R581.2 R587.1 R617.1 U38.44
SIO_LED0: R761.2 R762.2 U38.9
SIO_LED0_R: Q40.B R761.1
SIO_LED1: R750.1 R751.2 U38.8
SIO_LED1_R: Q39.B R750.2
SIO_PECI: R267.2 R702.2
SIO_PECI_R: C612.1 R702.1 U38.27
SIO_PWRON_L: PCH1.AT13 R697.1 U38.31
SIO_VCORE: C603.1 C604.1 U38.13
SIO_VREF: C580.2 R586.1 U38.47
SKTOCC_VBOOT: Q11.5 Q11.6 R526.2
SLP_AMT_L: ME_TEST.5 PCH1.BC15
SLP_LAN_L: PCH1.AV15 R292.2
SLP_S0_L: PCH1.BC26 STP72.1
SLP_S3_L: ME_TEST.2 PCH1.AW15 R305.1 R401.1 R517.1 U15.1 U20.5 U30.5 U33.1 U38.30 U40.5
SLP_S3_L_R: QN23.3 QN24.2
SLP_S4_L: ME_TEST.4 PCH1.BD15 R297.1 R385.2 R400.1 U38.35 U43.2
SLP_S4_L_R: QN19.1 R385.1
SLP_S4_L_R_D: Q39.E Q40.E QN19.3 R384.2
SLP_WLAN_L: PCH1.AV13 R682.1 STP74.1
SLPSUS_L: PCH1.BB13 R522.2 R523.1 U38.64
SLS3_BF: QN16.3 R302.1 R309.1 R319.1 R328.1 R340.1
SMBALERT_L: PCH1.BB41 R590.1 R596.1
SMBCLK_MAIN: QN33.2 R364.1 R717.1 R728.1
SMBCLK_STBY: C560.1 PCIE1X.B5 PCIE16X.B5 QN33.3 R570.1 R726.1 SR15.1
SMBCLK_STBY_R: PCH1.AW44 R570.2
SMBDATA_MAIN: QN35.2 R363.1 R707.1 R727.1
SMBDATA_STBY: C568.1 PCIE1X.B6 PCIE16X.B6 QN35.3 R584.1 R729.1 SR16.1
SMBDATA_STBY_R: PCH1.BB43 R584.2
SMCLK_DIMM: C395.1 DIMM1.118 DIMM2.118 R364.2
SMDATA_DIMM: C394.1 DIMM1.238 DIMM2.238 R363.2
SML0_CLK: PCH1.AY44 R591.1
SML0_DATA: PCH1.BB39 R634.1
SML0ALERT_L: PCH1.BA40 R585.1 R588.1
SML1_CLK: C574.1 PCH1.AW42 R595.2 U38.11
SML1_DATA: C571.1 PCH1.AW45 R580.2 U38.57
SML1ALERT_L: PCH1.AT27 R678.1 R679.1
SPI0_IO2: PCH1.BC29 SR27.1 SR29.1 SR31.1
SPI0_IO3: PCH1.BD30 R597.1 R610.1 R619.2
SPI_CLK: PCH1.BC31 R602.1
SPI_CLK0: R602.2 SPI_DEBUG.8 SPIROM1.6
SPI_CS_L0: PCH1.BD31 R763.1 SPI_DEBUG.3
SPI_IO2_0: C635.1 R748.2 SPI_DEBUG.7 SPIROM1.3 SR31.2
SPI_IO3_0: C640.1 R619.1 R758.2 R759.2 SPI_DEBUG.6 SPIROM1.7
SPI_MISO: PCH1.BE30 R598.1 R611.1 R620.1
SPI_MISO0: C637.1 R620.2 SPI_DEBUG.5 SPIROM1.2
SPI_MOSI: PCH1.BB29 SR26.1 SR28.1 SR30.1
SPI_MOSI0: C639.1 SPI_DEBUG.10 SPIROM1.5 SR30.2
SRTCRST_L: C587.1 PCH1.BB10 R604.2
SSD_100M_N: M2_2.53 PCH1.E5
SSD_100M_P: M2_2.55 PCH1.G4
SSD_DETECT: PCH1.AG36 R735.1
SSD_DETECT_L: M2_2.69 R734.1 R735.2
SUSACK_L: PCH1.BB19 R642.1 R643.1 R650.2
SUSACK_R: R643.2 U38.10
SUSCLK: PCH1.AN15 R539.1 R540.1 R544.1 SC57.1
SUSWARN_L: PCH1.BD19 R577.1 R578.1 R650.1
SUSWARN_R: R578.2 U38.55
SW_DIS_ME: Q21.E RJ3.3
SYS_FAN_P2: C480.1 EC30.1 Q22.C R420.1 R483.2 SYS_FAN.2
SYS_FAN_P3: D18.P R525.2 R527.1 SYS_FAN.3
SYS_FAN_P4: R538.2 SYS_FAN.4
SYS_THERM: C575.2 C581.1 R586.2 R587.2 U38.46
THERMAL_SD: PCH1.AE44 R545.1 U38.63
TP_AE17: PCH1.AE17 STP19.1
TP_AF17: PCH1.AF17 STP52.1
TP_AG14: PCH1.AG14 STP21.1
TP_AG15: PCH1.AG15 STP20.1
TP_AN17: PCH1.AN17 STP23.1
TP_AR19: PCH1.AR19 STP57.1
TP_AZA_PLLMON_N: PCH1.BE2 STP71.1
TP_AZA_PLLMON_P: PCH1.BD1 STP69.1
TP_CL_CLK: PCH1.AV2 TP16.1
TP_CL_DATA: PCH1.AV3 TP17.1
TP_CL_RST_L: PCH1.AW2 TP18.1
TP_DMIC_CLK_0: PCH1.AJ35 STP58.1
TP_DMIC_CLK_1: PCH1.AJ42 STP59.1
TP_DMIC_DATA_0: PCH1.AH44 TP13.1
TP_DMIC_DATA_1: PCH1.AJ38 STP55.1
TP_GPP_A12: PCH1.BB17 TP19.1
TP_GPP_A16: PCH1.AR17 STP25.1
TP_GPP_B_1: PCH1.AL27 STP70.1
TP_GPP_B_11: PCH1.AN24 STP56.1
TP_GPP_E5: PCH1.AG43 TP12.1
TP_GPP_E6: PCH1.AE45 TP11.1
TP_GPP_F7: PCH1.AB43 STP47.1
TP_GPP_F8: PCH1.AB36 STP50.1
TP_GPP_F9: PCH1.AB39 STP49.1
TP_GPP_F23: PCH1.V44 STP43.1
TP_GPP_G8: PCH1.R44 STP44.1
TP_GPP_G9: PCH1.R43 STP41.1
TP_GPP_G10: PCH1.U39 STP45.1
TP_GPP_G11: PCH1.N42 STP40.1
TP_GPP_G_17: PCH1.N44 STP42.1
TP_GPP_I3: PCH1.BA4 STP65.1
TP_L_BKLTCTL: PCH1.W36 STP48.1
TP_L_BKLTEN: PCH1.W35 STP46.1
TP_L_VDDEN: PCH1.W42 TP8.1
TP_PCH_AB13: PCH1.AB13 STP18.1
TP_PCH_AR22: PCH1.AR22 STP61.1
TP_VGA: R616.1 TP20.1 U38.5
TPM_P5: C618.2 LPC_DEBUG.5 R708.1
TPM_P6: LPC_DEBUG.6 R706.2 R707.2
TPM_P15: LPC_DEBUG.15 R719.1
TPM_P18: LPC_DEBUG.18 R718.1
TPM_P19: LPC_DEBUG.19 R715.1 R716.1
TPM_RSV2: LPC_DEBUG.20 R717.2
UGATE1_A: R221.1 U19.27
UGATE1_B: R293.1 U19.36
UGATE1A_G: QCH1.G R221.2 R222.2
UGATE1B_G: QCGH1.G R290.2 R293.2
UGATE1C_G: QCSH1.G R218.2 R227.2
UGATE2_A: R220.1 U19.31
UGATE2_B: R304.1 U27.1
UGATE2A_G: QCH2.G R220.2 R223.2
UGATE2B_G: QCGH2.G R303.2 R304.2
UGATE3_A: R278.1 U24.1
UGATE3A_G: QCH3.G R277.2 R278.2
USB2_COMP: PCH1.AG3 R467.1
USB2_ID: PCH1.AG2 R466.1
USB2_VBUSSENSE: PCH1.AD10 R465.1
USB3_RX_N1: CHOKE17.1 PCH1.B7 RN10.5(A)
USB3_RX_N1_R: CHOKE17.2 D20.4 D20.7 RN10.6(B) USB3F1.2
USB3_RX_N2: CHOKE18.1 PCH1.C8 RN10.1(A)
USB3_RX_N2_R: CHOKE18.2 D20.1 D20.10 RN10.2(B) USB3F1.18
USB3_RX_N3: CHOKE11.1 PCH1.B10 RN6.1(A)
USB3_RX_N3_R: CHOKE11.2 RN6.2(B) U12.1 U12.10 USB3X2.14
USB3_RX_N4: CHOKE12.1 PCH1.E11 RN6.5(A)
USB3_RX_N4_R: CHOKE12.2 RN6.6(B) U12.4 U12.7 USB3X2.5
USB3_RX_P1: CHOKE17.4 PCH1.A7 RN10.7(A)
USB3_RX_P1_R: CHOKE17.3 D20.5 D20.6 RN10.8(B) USB3F1.3
USB3_RX_P2: CHOKE18.4 PCH1.B8 RN10.3(A)
USB3_RX_P2_R: CHOKE18.3 D20.2 D20.9 RN10.4(B) USB3F1.17
USB3_RX_P3: CHOKE11.4 PCH1.A9 RN6.3(A)
USB3_RX_P3_R: CHOKE11.3 RN6.4(B) U12.2 U12.9 USB3X2.15
USB3_RX_P4: CHOKE12.4 PCH1.G11 RN6.7(A)
USB3_RX_P4_R: CHOKE12.3 RN6.8(B) U12.5 U12.6 USB3X2.6
USB3_TX_N1: C572.1 PCH1.C11
USB3_TX_N1_C: C572.2 CHOKE16.4 RN9.3(A)
USB3_TX_N1_R: CHOKE16.3 D19.4 D19.7 RN9.4(B) USB3F1.5
USB3_TX_N2: C569.1 PCH1.B12
USB3_TX_N2_C: C569.2 CHOKE15.1 RN9.5(A)
USB3_TX_N2_R: CHOKE15.2 D19.2 D19.9 RN9.6(B) USB3F1.15
USB3_TX_N3: C88.1 PCH1.C13
USB3_TX_N3_C: C88.2 CHOKE9.1 RN5.1(A)
USB3_TX_N3_R: CHOKE9.2 RN5.2(B) U13.1 U13.10 USB3X2.17
USB3_TX_N4: C90.1 PCH1.A14
USB3_TX_N4_C: C90.2 CHOKE10.1 RN5.5(A)
USB3_TX_N4_R: CHOKE10.2 RN5.6(B) U13.4 U13.7 USB3X2.8
USB3_TX_P1: C578.1 PCH1.B11
USB3_TX_P1_C: C578.2 CHOKE16.1 RN9.1(A)
USB3_TX_P1_R: CHOKE16.2 D19.5 D19.6 RN9.2(B) USB3F1.6
USB3_TX_P2: C561.1 PCH1.A12
USB3_TX_P2_C: C561.2 CHOKE15.4 RN9.7(A)
USB3_TX_P2_R: CHOKE15.3 D19.1 D19.10 RN9.8(B) USB3F1.14
USB3_TX_P3: C89.1 PCH1.D13
USB3_TX_P3_C: C89.2 CHOKE9.4 RN5.3(A)
USB3_TX_P3_R: CHOKE9.3 RN5.4(B) U13.2 U13.9 USB3X2.18
USB3_TX_P4: C91.1 PCH1.B13
USB3_TX_P4_C: C91.2 CHOKE10.4 RN5.7(A)
USB3_TX_P4_R: CHOKE10.3 RN5.8(B) U13.5 U13.6 USB3X2.9
USB10+: L21.4 M2_1.3
USB10-: L21.1 M2_1.5
USB+5: L8.4 U16.6 USB2_LAN.U7
USB+6: L7.4 U16.4 USB2_LAN.U3
USB+7: F_USB1.6 L25.4 RN13.6(B) U42.6
USB+8: F_USB1.5 L26.4 RN13.2(B) U42.4
USB+9: CMK1.1 F_USB2.3 U32.6
USB-5: L8.1 U16.1 USB2_LAN.U6
USB-6: L7.1 U16.3 USB2_LAN.U2
USB-7: F_USB1.4 L25.1 RN13.8(B) U42.1
USB-8: F_USB1.3 L26.1 RN13.4(B) U42.3
USB-9: CMK1.4 F_USB2.2 U32.1
USB_EN: R153.1 R213.1 R437.1 R460.2 R481.2 RJ4.2
USB_EN1: C489.1 R437.2 U30.4 U33.2 U40.4
USB_EN2: C126.1 R153.2 U15.2
USB_EN3: C186.1 R213.2 U20.4
USB_H1: CHOKE14.3 RN7.8(B) U14.3 USB3X2.12
USB_H2: CHOKE13.3 RN7.4(B) U14.1 USB3X2.3
USB_L1: CHOKE14.2 RN7.6(B) U14.4 USB3X2.11
USB_L2: CHOKE13.2 RN7.2(B) U14.6 USB3X2.2
USB_N1: CHOKE14.1 PCH1.AF5 RN7.5(A)
USB_N2: CHOKE13.1 PCH1.AD5 RN7.1(A)
USB_N3: CMK3.1 PCH1.AG8 RN11.3(A)
USB_N3_R: CMK3.2 RN11.4(B) U39.4 USB3F1.12
USB_N4: CMK2.1 PCH1.AE1 RN11.7(A)
USB_N4_R: CMK2.2 RN11.8(B) U39.1 USB3F1.8
USB_N5: L8.2 PCH1.AC2
USB_N6: L7.2 PCH1.AF2
USB_N7: L25.2 PCH1.AB3 RN13.7(A)
USB_N8: L26.2 PCH1.AL8 RN13.3(A)
USB_N9: CMK1.3 PCH1.AA1
USB_N10: L21.2 PCH1.AJ8
USB_OC2_L: PCH1.AD39 R511.1
USB_OC3_L: PCH1.AC44 R494.1 R502.1
USB_OC7_L: PCH1.W43 R444.1
USB_P1: CHOKE14.4 PCH1.AG7 RN7.7(A)
USB_P2: CHOKE13.4 PCH1.AD7 RN7.3(A)
USB_P3: CMK3.4 PCH1.AG10 RN11.1(A)
USB_P3_R: CMK3.3 RN11.2(B) U39.3 USB3F1.11
USB_P4: CMK2.4 PCH1.AE2 RN11.5(A)
USB_P4_R: CMK2.3 RN11.6(B) U39.6 USB3F1.9
USB_P5: L8.3 PCH1.AC3
USB_P6: L7.3 PCH1.AF3
USB_P7: L25.3 PCH1.AB2 RN13.5(A)
USB_P8: L26.3 PCH1.AL7 RN13.1(A)
USB_P9: CMK1.2 PCH1.AA2
USB_P10: L21.3 PCH1.AJ7
VBOOT_V1P05: C170.2 C175.2 R184.1 R185.2 U19.45
VBOOT_V1P05_Q: Q11.3 R184.2
VCORE_GSENS: C49.1 C85.2 CPU1.D38 R93.2 SR14.1 U19.20
VCORE_GT_GSENS: C171.2 C189.1 CPU1.F38 R202.2 U19.48
VCORE_GT_SENS: C181.1 C184.1 C188.2 C189.2 CPU1.F39 R201.1 R214.1
VCORE_READY: R156.1 R536.2 U19.11
VCORE_SENS: C38.2 C49.2 C71.1 C644.1 CPU1.C38 R37.1 R45.1 SR14.2
VGA_BLUE: C10.1 FB1.1 R26.1 U7.7
VGA_BLUE_CONN: C9.1 FB1.2 U2.3 VGA.3
VGA_DDCCLK_CNN: SC2.1 SR1.2 SR3.2 U1.3 VGA.15
VGA_DDCSDA_CNN: SC4.1 SR4.2 SR5.2 U1.1 VGA.12
VGA_GREEN: C22.1 FB2.1 R29.1 U7.8
VGA_GREEN_CONN: C21.1 FB2.2 U2.6 VGA.2
VGA_HSYNC: R24.1 U5.1 U5.2 U7.2
VGA_HSYNC_5V: R24.2 R25.1 U5.4
VGA_HSYNC_CNN: C8.1 R25.2 U1.6 VGA.13
VGA_RED: C29.1 FB3.1 R40.1 U7.9
VGA_RED_CONN: C28.1 FB3.2 U2.4 VGA.1
VGA_VSYNC: R22.1 U6.1 U6.2 U7.1
VGA_VSYNC_5V: R22.2 R23.1 U6.4
VGA_VSYNC_CNN: C7.1 R23.2 U1.4 VGA.14
VR_ENABLE: C127.1 C350.2 Q14.C R143.1 R325.1 R687.2 R690.2 U19.8 U22.3
VR_ENABLE_R: QN28.3 QN30.3 R686.1 R687.1 R692.1
VR_HOT_L: R159.1 SC16.1 SR9.2 SR13.1 U19.4
VR_READY: BT3.3 Q17.C R342.1 R497.1 R724.1 R725.1
VRALERT_L: PCH1.BD23 R626.1
VRD_THERMDA: C136.1 C582.1 Q9.B Q9.C U38.45
VRD_THERMDC: C136.2 C582.2 Q9.E R617.2
VREF: C24.1 CODEC.27
VSA_BST: R230.1 U22.10
VSA_BST_R: C211.2 R230.2
VSA_CS: R198.1 U22.2
VSA_FB: R195.1 R196.1 R197.1 U22.4
VSA_FB_R: C173.2 C180.2 R192.2 R196.2 R215.2
VSA_FB_RC: C180.1 R195.2
VSA_GSENS: R203.2 R300.2
VSA_LG: QCSL1.G U22.6
VSA_PH: C211.1 L15.1 QCSH1.S1 QCSH1.S2 QCSH1.S3 QCSL1.D1 QCSL1.D2 QCSL1.D3 QCSL1.D4 QCSL1.D5 R217.2 R218.1 U22.8
VSA_PWRGD: R199.1 R200.1 U22.1
VSA_READY: BT3.2 C529.2 R200.2
VSA_READY_R: BT3.1 C538.2 R536.1
VSA_RF: R216.1 U22.5
VSA_SENS: CPU1.AD5 R192.1
VSA_UG: R227.1 U22.9
VSA_VDD: C210.2 R229.1 U22.7
VSUMA+: C39.2 C40.2 R70.2 R91.1 R95.2 R114.1 R163.1 U19.18
VSUMA-: C39.1 C40.1 C53.2 C70.1 C74.1 C109.1 R46.2 R70.1 R71.1 R90.1 R94.2 R96.1 R97.1 R128.1 R147.1 RT2.2
VSUMB+: C174.2 C178.2 R205.2 R209.2 R210.2 R211.1 U19.50
VSUMB-: C167.1 C168.1 C174.1 C178.1 C193.2 R178.1 R179.1 R180.1 R186.1 R189.1 R205.1 R207.1 RT4.2
VTT_CNTL_D: QN14.D QN15.1 R322.2
VTT_CNTL_G: QN14.G R311.2
W_DISABLE: M2_1.56 R370.2 R371.2
WBT_LED_P1: R730.1 WBT_LED.1
WBT_LED_P2: R731.1 WBT_LED.3
WBT_LED_P4: Q36.E WBT_LED.4
WFLED-: Q34.E WBT_LED.2
WLAN_100M_N: M2_1.49 PCH1.L7
WLAN_100M_P: M2_1.47 PCH1.L5
WLAN_SW: C349.1 QN12.1 R312.2
WLAN_SW_C: QN12.3 R307.1 R308.2 R310.1
XCLK_BIASREF: PCH1.E1 R409.2
XDP_BPM_0: CPU1.D16 STP4.1
XDP_BPM_1: CPU1.D17 STP7.1
XDP_BPM_2: CPU1.G14 STP28.1
XDP_BPM_3: CPU1.H14 STP30.1
XTAL_24M_IN: PCH1.A6 SR36.2
XTAL_24M_OUT: PCH1.A5 SC42.1 SR17.2 SY1.1
N15926147: CLR_CMOS.3 R427.1
N15926841: D17.2 R434.1
N15926845: D17.1 R431.1 R433.2
N15932147: QN33.1 QN35.1 QN36.3 R741.2
N15932439: QN34.3 QN36.1 R736.2
N17027396: Q16.B R310.2
N17027596: C359.1 Q15.C QSW2.4 R306.2
N17027830: C360.1 Q16.C QSW2.2 R318.2
N17238456: QN15.3 R321.1 R326.2
N17804039: QN3.G R50.1
N17804048: F1.1 QN3.D R42.2
N18832986: Q35.C RN12.1(A) RN12.3(A) RN12.5(A) RN12.7(A)
N18833027: F_PANEL.11 R757.1
N18833215: C614.2 Q35.B R705.2
N18833356: Q22.B R477.1 R501.2
N18833892: F_PANEL.14 Q38.E
N18833899: F_PANEL.12 R755.2
N18833970: F_PANEL.6 R756.2
N18833998: Q37.B R745.1
N18834219: R477.2 U34.1
N19174289: PCH1.BA15 R615.1
N19734777: C551.2 Q30.G R554.1
N19734802: C522.2 Q27.G R462.1
N19735370: Q24.C R423.2 R424.1 R425.2 R441.2
N19735374: C493.2 Q24.B R438.2 R439.2
N19735396: Q25.B R423.1
N19735409: Q26.B R424.2
N19808359: C496.1 Q28.G QN21.3 R447.2
N19808385: QN22.3 R489.2 R490.2
N19808449: C521.1 QN22.1 R491.1
N19808451: C509.1 QN21.1 R456.1
N19808578: QN24.3 R520.2 R521.2
N19808587: R456.2 R491.2 R520.1
N19808632: C528.2 Q29.G R490.1
N19957125: Q18.B R340.2
N19957178: Q14.B R319.2
N19957214: Q17.B R328.2
N19957293: Q13.C R314.1
N19957299: Q13.B R309.2
N19957316: C346.2 QN16.1 R305.2
N19987352: QN27.3 QN28.1 R691.1
N19987362: QN29.3 QN30.1 R669.1
N19989670: C624.2 QN37.1 R725.2
N19989709: QN37.3 R743.2 U41.2
N19989711: R713.1 R714.1 R723.2 R724.2
N19992201: C381.2 QN18.1 R347.2
N19992217: QN17.1 QN18.3 R348.2
N19992251: QN17.3 R335.1 R345.2 R346.1 U29.2
N19992378: Q20.B R333.2 R334.2
N19992399: C364.2 R335.2 R336.1
N19992409: Q19.B R336.2
N19992437: Q19.E Q20.C
N20917186: R333.1 U29.4
N20947091: QN23.1 R517.2
N20949106: QN26.3 R668.2
N22018072: C228.1 QSW1.S R247.1 RJ2.2
N22021894: D15.3 R291.1 R292.1 U25.2
N22057574: D15.1 QN11.3 R294.2
N22270713: C593.1 R644.1 R663.2 R664.1
N22270719: Q33.B R644.2
N22270721: Q32.B Q33.C R639.2
N22609430: C559.2 C563.2 PFB10.1 R571.1 U38.53
N22609694: QN25.3 R571.2
N22612262: R703.2 U38.28
N22676366: C201.2 R219.1 X1.1
N22733539: Q15.B R307.2
N23068703: R592.2 U37.8
N23126868: QN31.3 QN32.1 R670.1
N23126874: QN32.3 R689.1 R690.1
N23257413: C477.2 R419.2
N23257447: C447.2 L22.1 R402.2 U31.12
N23257449: C447.1 R395.2
N23257629: C476.2 R428.1 U31.17
N23257631: R410.1 U31.2
N23257661: C466.1 R402.1 R403.1 R404.2 U31.3
N23257703: C444.2 C445.2 R396.1 R397.2 U31.9
N23257707: C444.1 R397.1 U31.10
N23257717: R419.1 U31.16
N23257719: C477.1 U31.14
N23257723: R399.1 U31.7
N23257741: C464.2 U31.1
N23263015: M2_1.55 R354.1
N23413084: Q21.C R361.1
N23413086: Q21.B R359.1
N23474071: QN10.G R125.1
N23474079: F2.1 QN10.D R120.2
N23543471: C537.2 R533.1
N23749903: R317.1 U28.10
N23749907: C353.2 R317.2
N23749919: C353.1 L19.1 R315.1 U28.8 U28.9 U28.15 U28.16
N23749953: R332.2 R337.2 R338.1 U28.12
N23749979: C352.1 R315.2 R338.2
N23750037: C368.2 C370.2 C371.2 C380.2 L20.2 R341.2 U28.1
N23750263: R330.2 U28.3
N23750267: C356.1 R323.2 R330.1 U28.11
N23754361: R327.2 R331.1 R332.1
N23886367: R723.1 U41.4
N24048876: Q44.C R100.2
N24049205: C133.2 R167.1 U19.32
N24049230: C94.2 R117.1 U19.13
N24049234: C166.1 R178.2 U19.49
N24049240: C104.1 R131.2
N24049248: R131.1 U19.25
N24049260: R145.1 U19.29
N24049270: C125.1 R145.2
N24049276: C137.1 R170.2
N24049291: R170.1 U19.37
N24049344: R95.1 RT2.1
N24049350: C52.2 R94.1 U19.19
N24049369: C52.1 R46.1
N24049420: R116.2 R117.2
N24049428: R121.2 R122.2 RT1.2
N24049447: R121.1 U19.12
N24049451: R166.2 R175.2
N24049453: C149.2 R175.1 U19.3
N24049485: R165.2 R174.2 RT3.2
N24049503: R165.1 U19.2
N24049550: R210.1 RT4.1
N24049562: C166.2 R186.2
N24049624: R135.2 U19.10
N24049675: C184.2 R194.2
N24049677: C170.1 R193.1 R194.1 R201.2 R204.2 U19.46
N24049689: C187.2 R204.1
N24049710: C72.2 C73.2 R92.2 U19.23
N24049720: C73.1 R45.2 R66.2 R67.2 R111.1 U19.22
N24049728: C72.1 R111.2
N24049736: R110.2 U19.21
N24049738: C644.2 R67.1
N24049758: C37.2 R66.1
N24049870: C175.1 R193.2
N24049911: C71.2 R110.1
N24049917: R182.1 U19.47
N24049919: C181.2 R182.2
N24053069: QN39.3 R313.1 R320.1 R329.1
N24053357: R73.1 R91.2
N24053944: C240.2 R261.1 U24.6 U24.7
N24054034: R163.2 R164.1
N24054595: R272.1 U24.2
N24054604: R114.2 R115.1
N24061533: R208.1 R209.1
N24061699: R211.2 R212.1
N24062859: C320.2 R296.1 U27.6 U27.7
N24062865: R301.1 U27.2
N24625806: D25.3 QN40.1
N24707255: Q44.B R343.1
N24718617: C265.2 R281.1

Pads without a net: ATX_POWER 12 14 20; CODEC 2 18 19 20 31 33 37 39 41 43 44 45 46 48; CPU1 1 2 3 4 5 6 7 8 9 10 11 12 13 14 15 16 A16 AB37 AB38 AC37 AJ24 AJ25 AJ26 AJ27 AJ28 AJ29 AJ30 AK21 AK22 AK27 AL15 AL25 AL26 AM15 AM25 AM26 AN17 AN20 AN21 AN25 AN26 AP15 AP19 AP20 AP25 AP26 AR25 AR26 AT16 AT33 AU9 AU10 AU12 AU16 AU29 AU31 AU32 AU33 AU39 AU40 AV10 AV13 AV16 AV24 AV25 AV31 AV32 AV33 AV39 AW16 AW29 AW31 AW33 AW38 AY10 AY31 B16 B17 C9 C17 D9 D10 D12 D14 D15 E10 E12 F9 F35 F36 F37 G9 G10 G34 G35 H10 H11 H12 H33 H34 J11 J13 J14 J15 J33 J35 K11 K32 K34 L31 L33 M32; DIMM1 39 40 42 43 45 46 48 49 53 68 79 126 135 144 153 158 159 162 164 165 167 187 198 204 213 222 231; DIMM2 39 40 42 43 45 46 48 49 53 68 79 126 135 144 153 158 159 162 164 165 167 187 198 204 213 222 231; F_PANEL 9 13; F_USB1 10; HDMI1 13 14; HDMI2 13 14; LPC_DEBUG 13 14; M2_1 8 9 10 11 12 13 14 15 17 19 20 21 22 23 32 34 36 38 40 42 44 46 48 59 61 62 64 65 66 67 68 70 71 73; M2_2 5 6 7 8 9 10 11 20 22 23 24 25 26 28 30 32 34 36 40 42 44 46 48 56 58 59 60 61 62 63 64 65 66 67; ME_DISABLE 1; PCH1 A16 A21 A35 AB42 AD2 AD3 AJ11 AJ13 AJ33 AJ39 AJ43 AJ44 AK44 AK45 AL35 AL36 AL42 AL43 AL44 AM43 AM44 AN29 AN42 AN43 AN44 AR15 AR24 AR29 AR38 AR39 AR41 AR44 AR45 AT31 AT42 AT43 AT44 AU41 AU43 AV29 AW27 AW31 B14 B15 B16 B19 B20 B21 B31 B33 B35 B38 BB22 BB38 BC8 BC19 BC22 BC27 BC38 BD14 BD18 BD21 BD22 BD38 BE21 BE39 C1 C14 C15 C19 C20 C31 C33 C38 D1 D7 D8 D39 E17 E20 E37 E45 F45 G13 G15 G17 G19 G31 G33 G37 G44 G45 H13 H15 H31 H33 H40 H42 H43 H44 J45 K13 K15 K17 K31 K37 K44 L17 L31 L37 L39 N2 N3 N7 N8 N29 N31 N38 N39 P1 P2 P3 P24 P27 P29 P31 R2 R3 R4 R7 R8 R11 R13 R24 R27 U2 U3 U5 U7 U13 V1 V2 W2 W3 W7 W13 Y5; PCIE1X A5 A6 A7 A8 B9 B12; PCIE16X A5 A6 A7 A8 A19 A32 A33 A50 B9 B12 B30 B82; U2 1; U7 4; U8 6; U11 6; U15 6; U19 39 41; U20 6; U25 1; U28 5 6; U29 1; U30 6; U31 15; U32 3 4; U33 6; U34 7; U36 1; U37 4 6 10 11 12 13 14; U38 59; U40 6; U41 1; U43 5; USB3F1 10; VGA 4 11 16

## Via types
v1: diameter 0.61, hole 0.305, TOP to BOTTOM, 3115 vias
v2: diameter 0.762, hole 0.381, TOP to BOTTOM, 357 vias
v3: diameter 0.508, hole 0.254, TOP to BOTTOM, 596 vias
v4: diameter 0.457, hole 0.254, TOP to BOTTOM, 32 vias
v5: diameter 0.559, hole 0.305, TOP to BOTTOM, 513 vias
v6: diameter 1.016, hole 0.508, TOP to BOTTOM, 30 vias

## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point)
3VR_GO: length 4.7
  TOP w0.102: R704.1 137.86,27.31 R693.2 C609.2 139.04,26.47 v2(139.19,26.31) 139.34,26.16 140.36,26.16 QN29.1
3VSBSW_L: length 113.3
  TOP w0.102: U38.37 116.94,32.64 118.01,31.57 118.01,31.01 119.25,29.77 120.62,29.77 120.94,29.45 120.94,28.69 121.64,27.99 122.38,27.99 123.75,29.36 123.75,31.67 v1(124.64,32.56) ; R440.2 161.71,63.15 R439.1 161.52,62.18 161.85,61.85 167.11,61.85 170.03,58.93 170.03,45.85 165.91,41.73 165.91,34.24 164.44,32.77 164.44,20.85 v1(164.9,20.4)
  BOTTOM w0.102: v1(124.64,32.56) 129.29,27.91 131.06,27.91 138.89,20.09 163.53,20.09 v2(163.83,20.4) v1(164.9,20.4)
5VDLA: length 10.8
  TOP w0.381: 159.41,74.63 QN20.3
  TOP w0.508: 159.41,74.63 158.62,73.84 v2(158.62,72.19) 158.62,70.42 R411.2 C474.1 157.55,65.88 Q25.C
5VDLSB: length 7
  TOP w0.508: R415.2 C469.2 165.8,69.44 Q23.G v1(167.49,68.83) Q26.C
12VR_GO: length 7.4
  TOP w0.102: R667.2 132.84,29.5 v1(133.2,29.13)
  TOP w0.254: R667.2 R666.1 C602.2 128.88,28.86 128.88,26.24 QN27.1
+1V05_SA: length 28.7
  TOP w0.254: v1(92.84,197.56) 92.84,198.25 92.04,199.04 R215.1
  TOP w0.305: v5(111.48,148.31) CPU1.Y8 ; v5(110.39,152.6) CPU1.R7 v5(110.39,153.52) ; CPU1.N7 v5(110.39,154.43)
  TOP w0.356: v5(110.39,154.43) CPU1.P7 ; CPU1.Y6 v5(109.47,148.95) CPU1.Y7 ; v5(109.47,149.86) CPU1.W7 ; CPU1.T7 v5(110.39,152.6)
  TOP w0.381: CPU1.V7 v5(109.47,149.86) ; v5(110.39,151.69) CPU1.U7
  BOTTOM w0.254: 104.67,187.02 103.38,187.02 100.66,189.74 95.83,189.74 92.1,193.47 92.1,196.82 v1(92.84,197.56)
  vias: v1(104.75,185.62) v1(104.77,183.26) v1(106.35,186.79) v1(107.72,183.77) v1(107.77,185.83) v1(109.07,181.36) v1(109.73,186.16) v1(110.34,181.36) v1(110.59,183.13) v1(114.05,150.7) v1(114.02,149.73) v1(114.02,148.72) v1(114.02,146.94) v1(116.43,178.08) v1(116.46,180.7) v1(117.58,179.32) v1(124.31,170.94) v1(124.94,170.18) v1(125.58,169.55) v1(125.65,173.43) v1(125.83,168.53) v1(126.44,172.52) v1(126.77,167.56) v1(127.33,171.55) v1(127.33,169.52) v5(109.47,148.06) v5(110.39,148.06) v5(112.29,146.89) v5(112.37,147.83)
+1V8_AVCC: length 10.8
  TOP w0.203: 190.96,225.58 190.64,225.9 U7.21
  TOP w0.381: C34.1 v1(193.05,223.82)
  TOP w0.406: C34.1 192.82,224.66 191.62,224.66 190.96,225.32 190.96,225.58
  BOTTOM w0.381: v1(193.05,223.82) 192.51,223.82 191.29,225.04 191.29,228.04 v2(191.67,228.42) v1(192.28,229.03)
+1V8_IVDD: length 57.3
  TOP w0.203: U7.20 190.04,225.3 190.6,224.74 ; 186.13,224.87 186.16,224.87 186.44,225.15 U7.11 ; 186.51,231.75 186.41,231.65 186.41,231.17 186.84,230.74 U7.39 ; C5.1 187.37,232.57 187.93,232 187.93,231.32 187.64,231.02 U7.37
  TOP w0.254: C43.1 191.24,223.39 191.24,221.87 191.44,221.67 191.44,221.36 189.38,221.36 188.47,222.28 188.47,222.99 188.11,223.34 186.89,223.34 186.14,224.1 C41.1
  TOP w0.381: C41.1 185.88,224.61 ; C43.1 191.34,223.97 ; 191.44,221.36 191.44,220.14 v1(190.3,219) ; v1(190.45,235.66) 190.25,235.86 185.45,235.86 184.58,234.99 PFB1.2 184.58,233.94 185.79,232.73 C4.1 187.01,232.73 C5.1
  TOP w0.406: 185.88,224.61 186.13,224.87 ; C5.1 187.07,232.57 186.51,232.01 186.51,231.75 ; 191.34,223.97 190.6,224.71 190.6,224.74
  BOTTOM w0.381: v1(190.45,235.66) 191.72,234.39 v2(191.72,233.43) 191.72,232.69 196.55,227.86 196.55,221.34 194.21,219 v1(190.3,219)
+1V8_IVDDO: length 29.1
  TOP w0.203: U7.32 189.64,230.73 189.86,230.96 189.86,230.99
  TOP w0.381: v1(183.97,233.6) 183.62,233.95 PFB1.1 183.62,235.03 185.04,236.45 190.65,236.45 191.36,235.74 191.36,233.67 C2.1 ; PFB3.1 v1(182.35,231.19)
  TOP w0.406: C2.1 190.51,231.14 190.01,231.14 189.86,230.99
  TOP w0.508: C2.1 192.9,232.83 v1(193.24,233.17) ; v1(196.75,228.7) 196.73,228.68 PFB4.1
  BOTTOM w0.381: v1(183.97,233.6) 183.97,232.82 v2(183.34,232.18) v1(182.35,231.19)
  BOTTOM w0.508: v1(196.75,228.7) 193.24,232.21 v1(193.24,233.17)
+1V8_VDDC: length 1
  TOP w0.203: 185.39,227.69 U7.6 ; U7.5 185.25,228.09
+3V3_IVDD:
  vias: v2(192.07,230.81)
+3V3_OVDD: length 30.8
  TOP w0.203: U7.40 185.89,230.29 v1(185.85,230.33) ; C33.1 184.76,224.66 185.34,225.25 185.34,225.86 185.58,226.09 U7.10
  TOP w0.254: v1(175.36,230.91) 175.49,230.78 175.49,227.91 175.97,227.43 175.97,225.37 176.4,224.94 176.4,224.28 177.2,223.49 C45.1 PFB6.2
  TOP w0.381: PFB6.2 184.12,224.63 C33.1
  BOTTOM w0.254: v1(175.36,230.91) 181.51,230.91 182.37,230.05 183.51,230.05 184.12,230.66 v2(184.91,230.66) 185.52,230.66 v1(185.85,230.33)
+3VSB: length 1051.5
  TOP w0.203: R729.2 46.51,24.28 v1(46.48,24.31) 46.18,24.61 44.81,24.61 44.48,24.28 R726.2 ; PCH1.AN5 52.78,48.13 v3(52.79,48.05) ; v3(59.34,45.14) PCH1.BA20
  TOP w0.254: v1(155.45,21.62) 155.45,26.75 154.36,27.84 ; v3(70.63,49.08) PCH1.AL41 ; v3(70.15,50.07) PCH1.AJ41 ; v1(103.66,32.54) 103.25,32.54 102.92,32.21 R642.2 ; v1(125.09,34.19) 125.04,34.14 R622.2 ; v3(70.21,43.94) 70.02,43.75 PCH1.BD40 70.78,43.42 PCH1.BC42 ; R669.2 141,29.46 140.61,29.08 140.61,27.66 141.55,26.72 v1(141.55,21.74) ; U26.4 70.71,146.79 C321.1 70.15,144.7 70.15,144.09 61.47,135.41 57.96,135.41 57.43,134.87 50.9,134.87 v1(49.68,133.65) ; v1(16.46,85.95) 7.61,94.8 7.61,103.33 R361.2 ; R691.2 132.95,28.29 v1(133.05,28.19) ; 154.36,27.84 153.98,27.46 R688.2 ; 154.36,27.84 154.36,28.87 R670.2 ; PCH1.AD41 v3(70.15,52.53) ; v1(132.82,21.13) 132.82,22.83 135.2,25.22 v1(135.2,25.25) ; R521.1 138.15,51.56 138.61,52.02 141.3,52.02 142.98,53.7 143.51,53.7 ; R369.1 R370.1 32.49,98.2 32.49,98.83 32.12,99.2 30.77,99.2 29.9,100.08 25.76,100.08 24.99,99.31 23.83,99.31 23.57,99.06 23.57,96.6 v1(23.8,96.37) ; 51.66,122.11 C358.1 50.85,122.92 50.85,124.26 51.92,125.32 51.92,128.02 52.84,128.94 R308.1
  TOP w0.381: C623.2 48.87,19.08 49.48,18.47 49.48,17.7 R736.1 ; C623.2 49.71,19.17 50.15,18.73 U41.5 ; C623.2 v1(48.87,19.91) ; R631.2 76.3,34.26 76.73,34.7 v1(76.73,35.1) ; v1(88.01,42.04) 88.26,42.28 R565.2 ; R657.2 78.45,29.87 76.31,29.87 R654.2 ; RJ7.1 72.87,34.29 v1(73.71,35.13) 74.02,35.43 R614.2 ; R674.1 69.01,27.84 69.95,26.9 v1(71.98,26.9) ; R625.2 60.38,32.98 60.84,32.51 v1(60.88,32.51) 61.44,33.07 R626.2 ; v1(188.24,125.35) 188.29,125.3 R322.1 ; R588.2 82,40.11 v1(80.54,40.11) ; v1(88.93,47.75) 89.61,47.07 89.61,46.18 89.05,45.62 R549.2 ; R579.2 v1(86.51,41.17) R580.1 ; v1(40.74,187.43) 44.17,187.43 44.81,186.79 44.81,185.27 50.6,179.48 60.45,179.48 v1(61.26,178.66) ; R615.2 55.8,35.48 56.57,34.72 v1(56.57,34.62) ; 51.66,122.11 QSW2.3 51.66,119.1 51.31,118.75 49.99,118.75 49.73,119 49.73,120.8 48.29,122.25 48.29,129.06 49.53,130.3 v1(49.94,130.3)
  TOP w0.406: v1(88.93,51.21) 88.23,51.21 R510.1 88.21,51.37 R504.2 R503.2 ; R412.1 v1(86.21,69.22) ; v1(86,48.31) 85.45,47.75 R534.2 R530.2 ; R678.2 73.2,26.9 v1(71.98,26.9) ; v1(89.05,62.84) 88.77,63.12 R443.1 R445.2 ; R680.2 76.35,27.51 v1(76.35,26.92) ; v1(81.86,50.19) 81.38,50.67 R511.2 ; v1(88.93,47.75) R535.2 R531.1 ; v1(82.88,51.71) 83.41,51.18 R509.2 ; R478.2 81.69,54.61 v1(82.02,54.28) ; R458.2 v1(86.08,56.9) 87.22,55.75 R464.1 ; R461.2 v1(81.91,56.26) ; v1(86.08,54.61) R479.1 R463.1 ; R422.2 v1(86.21,66.55) R421.1 ; R444.2 R442.1 86.11,63.12 v1(86.28,62.94) ; v1(89.33,60.33) R449.2 ; R610.2 v1(66.7,36.45) R611.2 ; R595.1 86.08,37.97 v1(86.11,38) 86.13,37.97 R596.2 ; R496.1 v1(88.93,53.47) ; v1(86.21,65.41) R429.1 R435.1
  TOP w0.508: v1(184.45,122.96) 183.67,122.96 R326.1 ; v1(188.54,111.35) 187.86,112.03 R348.1 ; v1(37.16,205.89) 35.98,207.07 v1(35.98,209.49) ; v1(20.88,188.04) 23.62,188.04 24.71,186.94 31.8,186.94 32.44,186.31 C231.1 33.25,186.31 33.25,187.55 C226.1 33.63,187.67 34.01,187.29 34.87,187.29 35.28,187.71 35.28,188.61 PCIE1X.B10 ; v1(189.41,89) 186.97,89 183.96,85.99 183.96,76 v1(184.66,75.31) ; v1(118.69,23.77) v1(118.69,25.43) 118.14,25.98 R698.2 ; v1(76.73,35.1) 76.5,35.1 75.92,35.69 RJ6.1 ; 3.45,107.31 3.45,107.19 4.6,106.05 5.77,106.05 6.05,106.32 ; 3.45,107.31 v1(3.45,108.33) ; 3.45,107.31 1.68,105.54 1.68,83.87 2.72,82.83 2.72,69.55 1.96,68.78 1.96,17.53 v1(2.03,17.45) ; v1(1.6,11.51) 1.6,4.52 5,1.12 16.94,1.12 17.88,2.06 27,2.06 29.01,4.06 29.01,7.72 29.06,7.77 29.06,7.81 33.62,12.37 38.67,12.37 41.94,9.1 41.94,8.51 42.86,7.58 50.33,7.58 51,8.25 51.77,8.25 52.25,7.77 53.64,7.77 54.56,8.69 v1(54.56,9.04) ; v1(50.72,12.6) 50.72,13.44 50.97,13.68 R743.1 51.31,13.69 51.94,14.33 51.94,15.9 v1(51.79,16.05) ; v1(71.98,26.9) R716.2 ; v1(125.09,21.13) 121.87,21.13 v1(121.31,21.69) ; R674.1 68.17,27.13 68.17,19.46 71.22,16.41 R740.2 71.76,16.04 D22.2 D22.1 ; 9.5,139.98 8.1,138.58 7.44,138.58 6.46,137.6 6.46,136.58 v1(5.21,135.32) 3.94,135.32 R302.2 3.91,138.56 ME_TEST.3 ; v1(76.35,26.92) 76.56,26.72 C620.1 R719.2 ; 6.05,106.32 6.05,107.87 6.84,108.67 R356.2 ; 6.05,106.32 6.32,106.32 7.21,105.44 7.21,103.73 R361.2 ; RJ1.1 v1(20.17,209.17) ; R635.2 R634.2 80.37,32.03 v1(80.14,31.8) 80.14,31.55 R657.2 ; v1(162.13,62.36) 162.66,62.89 R440.1 R441.1 ; v1(114.63,25.1) 114.63,25.63 R703.1 ; v1(48.25,44.06) 47.09,42.9 47.09,40.82 45.25,38.98 R601.1 ; v1(40.32,220.09) Q6.E 40.61,218.99 41.29,219.68 R89.1 ; v1(110.21,42.6) 110.21,42.34 R577.2 ; R591.2 81.2,37.84 R599.1 80.98,37.12 v1(80.98,36.7) ; R316.1 v1(184.45,125.35) ; R651.1 69.58,30.42 v1(69.8,30.63) ; R494.2 R478.2
  TOP w1.016: 11.15,186.18 9.37,184.4 9.37,167.39 12.04,164.72 12.04,142.52 9.5,139.98
  BOTTOM w0.254: v3(59.34,45.14) 59.34,45.14 59.34,44.84 59.52,44.66 59.52,43.29 59.05,42.82 59.05,40.89 58.32,40.16 58.32,36.5 56.57,34.75 v1(56.57,34.62) ; v1(23.8,96.37) 23.8,95.05 24.46,94.39 24.46,89.79 20.62,85.95 v1(16.46,85.95) ; v1(125.09,34.19) 125.09,33.86 129.49,29.46 131.78,29.46 v1(133.05,28.19) 133.05,27.41 v1(135.2,25.25) 138.84,21.62 141.43,21.62 v1(141.55,21.74) 141.66,21.84 155.22,21.84 v1(155.45,21.62) ; v1(88.93,47.75) 88.39,48.29 88.39,50.67 v1(88.93,51.21) v1(88.93,53.47) ; v1(46.05,47.27) 46.35,47.27 47.65,48.56 52.28,48.56 v3(52.79,48.05)
  BOTTOM w0.381: v3(70.88,41.83) 70.88,42.5 70.21,43.17 v3(70.21,43.94) ; v1(51.79,16.05) 51.79,17.35 49.23,19.91 v1(48.87,19.91) ; v1(61.26,178.66) 61.01,178.66 49.68,167.34 v1(49.68,133.65) 49.68,130.56 v1(49.94,130.3) ; v3(70.15,52.53) 70.5,52.53 71.06,51.98 72.12,51.98 72.39,51.71 76,51.71 ; v1(188.24,125.35) v1(184.45,125.35) ; PCIE1X.B10 39.61,189.39 40.11,188.9 40.11,188.06 v1(40.74,187.43)
  BOTTOM w0.508: 72.22,48.92 75.18,48.92 v1(76.12,47.98) ; 72.22,48.92 SC52.2 ; 72.22,48.92 70.79,48.92 v3(70.63,49.08) 70.63,49.59 v3(70.15,50.07) ; v1(48.87,19.91) 48.87,20.57 49.38,21.08 v1(49.89,21.08) ; 76,51.71 78.99,51.71 79.76,50.95 79.76,48.77 v1(78.94,47.96) ; v1(76.73,35.1) 76.58,35.26 76.58,37.52 v1(75.9,38.2) ; v1(86,48.31) 85.55,47.85 83.37,47.85 81.86,49.36 v1(81.86,50.19) 82.88,51.21 v1(82.88,51.71) 82.88,53.42 v1(82.02,54.28) 81.91,54.38 v1(81.91,56.26) 82.55,56.9 v1(86.08,56.9) v1(86.08,54.61) ; v1(118.69,23.77) 120.78,21.69 v1(121.31,21.69) ; 19.74,192.46 19.74,193.95 20.17,194.39 21.39,194.39 21.89,194.89 21.89,197.76 28.7,204.57 35.84,204.57 v1(37.16,205.89) ; v1(50.72,12.6) 50.72,12.45 52.03,11.14 52.26,11.14 54.36,9.04 v1(54.56,9.04) ; v1(103.66,32.54) 110.75,32.54 111.23,32.06 111.23,26.72 111.94,26.01 113.72,26.01 v1(114.63,25.1) 114.63,24.69 115.09,24.23 115.9,24.23 116.56,24.89 116.56,25.37 117.04,25.86 118.26,25.86 v1(118.69,25.43) ; R611.2 v1(66.7,36.45) R610.2 ; v1(3.45,108.33) 3.45,128.54 5.21,130.29 v1(5.21,135.32) ; v1(2.03,17.45) 1.45,16.87 1.45,11.66 v1(1.6,11.51) ; v1(154.13,61.52) 155.17,62.56 158.57,62.56 159.18,63.17 161.32,63.17 v1(162.13,62.36) ; v1(125.09,21.13) v1(132.82,21.13) 142.7,11.25 142.7,11.2 148.87,11.2 150.37,12.7 153.67,12.7 155.42,10.95 171.17,10.95 184.25,24.03 184.25,44.83 186.18,46.76 186.18,57.4 185.64,57.95 185.64,63.11 184.4,64.34 184.4,75.06 v1(184.66,75.31) ; v1(184.45,125.35) v1(184.45,122.96) 184.45,121.56 188.32,117.7 188.32,111.58 v1(188.54,111.35) 189.41,110.49 v1(189.41,89) ; v1(20.17,209.17) 21.18,208.15 34.65,208.15 v1(35.98,209.49) 40.32,213.82 v1(40.32,220.09)
  vias: v1(143.87,55.63) v1(143.87,54.74) v1(144.63,55.63) v1(144.63,54.74) v1(145.39,55.63) v1(145.39,54.74) v3(71.86,41.15)
