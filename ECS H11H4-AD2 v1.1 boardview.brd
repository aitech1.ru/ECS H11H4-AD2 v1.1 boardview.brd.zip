# Allegro board ECS H11H4-AD2 v1.1 boardview.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
N19992409: length 3.1
  TOP w0.102: R336.2 188.66,120.53 Q19.B v1(191.1,119.18)
N19992437: length 3.1
  TOP w0.102: Q20.C 189.34,117.15 Q19.E v1(191.1,117.15)
N20917186: length 2.7
  TOP w0.102: R333.1 184.23,120.27 v1(183.52,119.56) 183.91,119.18 U29.4
N20947091: length 2.6
  TOP w0.102: v1(133.26,47.04) QN23.1
  TOP w0.254: R517.2 133.45,48.18 QN23.1
N20949106:
  vias: v2(165.86,28.07)
N22018072: length 5.6
  TOP w0.508: C228.1 53.03,187.83 QSW1.S 53.95,186.37 R247.1 v1(53.89,185.29) 53.89,184.47 RJ2.2
N22021894: length 7.6
  TOP w0.254: U25.2 5.31,153.31 4.39,152.4 v2(4.04,152.4) 3.94,152.3 R291.1 R292.1 3.94,147.51 D15.3
N22057574: length 4.3
  TOP w0.102: R294.2 5.72,145.86 D15.1 6.28,146.41 v1(6.28,147.27) 6.33,147.32 QN11.3
N22270713: length 4.6
  TOP w0.102: R663.2 C593.1 R644.1 R664.1 93.78,30.48 v1(94.54,29.72)
N22270719: length 3.1
  TOP w0.102: v1(97.38,31.37) 96.8,31.95 Q33.B 95.02,31.95 R644.2
N22270721: length 9.1
  TOP w0.102: v1(97.64,33.32) 97.08,32.77 94.74,32.77 R639.2 ; v1(97.64,33.32) 97.64,34.59 96.67,35.57 Q32.B ; v1(97.64,33.32) 98.45,32.51 Q33.C
N22609430: length 23.6
  TOP w0.178: U38.53 113.39,39.78
  TOP w0.254: PFB10.1 112.62,44.01 v2(112.62,45.14) 112.19,45.57 106.6,45.57 105.79,44.75 103.63,44.75 103.23,44.35 103.23,43.84 102.34,42.95 102.34,41.78 102.97,41.15 R571.1
  TOP w0.508: PFB10.1 111.89,43.27 111.89,41.82 C563.2 112.74,41.15 114.27,41.15 C559.2 113.39,40.21 113.39,39.78
N22609694: length 2.1
  TOP w0.102: R571.2 103.29,42.48 v1(103.78,42.98) 104.11,43.31 QN25.3
N22612262: length 3.4
  TOP w0.102: R703.2 114.38,27.69 113.39,28.67 U38.28
N22676366: length 5.2
  TOP w0.152: X1.1 61.67,198.6 61.44,198.38 C201.2 R219.1
N22733539: length 1.7
  TOP w0.102: R307.2 51.16,128.17 Q15.B
N23068703: length 2.3
  TOP w0.102: U37.8 96.37,40.51 R592.2 v2(95.4,39.21)
N23126868: length 4.8
  TOP w0.102: R670.1 155.9,28.65 QN31.3 156.3,27.31 v1(156.77,27.31) QN32.1
N23126874: length 3.5
  TOP w0.102: R690.1 R689.1 v1(160.1,28.42) 159.09,28.42 QN32.3
N23257413: length 1.9
  TOP w0.508: C477.2 142.53,66.29 R419.2
N23257447: length 13.1
  TOP w0.254: v1(150.39,72.14) R402.2
  BOTTOM w0.254: v1(139.8,76.07) 140.79,76.07 142.67,74.19 148.03,74.19 150.09,72.14 v1(150.39,72.14)
  vias: v1(134.29,75.26) v1(135.56,75.77) v1(136.83,74.88) v1(136.83,72.59) v1(140.54,75.41) v1(140.82,73.91)
N23257449: length 1.6
  TOP w0.635: C447.1 139.04,78.49 139.17,78.61
N23257629: length 5.7
  TOP w0.203: U31.17 144.17,68.98 144.63,68.53 C476.2 144.09,67.76 144.09,66.67 R428.1
N23257631: length 6.4
  TOP w0.203: U31.2 147.15,72.28 148.16,71.27 149.84,71.27 150.29,70.82 v2(150.29,69.8) 151.21,69.8 R410.1
N23257661: length 9.8
  TOP w0.203: C466.1 R404.2 153.42,71.32 152.78,71.96 v2(152.23,71.96) R403.1 150.65,71.6 149.13,71.6 R402.1 147.78,72.14 147.23,72.68 U31.3
N23257703: length 4.8
  TOP w0.203: 145.77,75.49 145.77,76.74 C445.2 145.45,78.33 C444.2 R397.2
  vias: v2(147.45,77.29)
N23257707: length 5.2
  TOP w0.102: v1(143.66,79.25) 143.66,77.83 R397.1
  TOP w0.203: R397.1 C444.1 145.37,77.26 U31.10
N23257717: length 3.4
  TOP w0.203: 143.59,69.98 143.77,70.16 U31.16
  TOP w0.508: R419.1 143.1,69.49 143.59,69.98
N23257719: length 3.6
  TOP w0.203: 142.44,70.28 142.97,70.81 U31.14
  TOP w0.508: C477.1 141.83,68.4 v2(141.83,69.67) 142.44,70.28
N23257723: length 3.1
  TOP w0.203: R399.1 148.46,75.82 v1(147.94,75.3) 147.94,74.94 147.28,74.28 U31.7
N23257741: length 2.8
  TOP w0.203: U31.1 146.99,71.88 147.41,71.46 v1(147.41,71.13) 147.8,70.74 C464.2
N23263015: length 3
  TOP w0.102: M2_1.55 32.94,111.9 v2(32.77,111.73) 31.74,110.71 R354.1
N23413084: length 3.4
  TOP w0.102: R361.1 5.99,103.99 Q21.C 5.82,105.13 v1(4.22,105.13)
N23413086: length 1.5
  TOP w0.102: R359.1 8.06,107.24 Q21.B
N23474071: length 2.5
  TOP w0.102: v2(120.24,212.6) R125.1 120.47,213.87 QN10.G
N23474079: length 8.4
  TOP w0.102: v2(122.66,217.42) QN10.D
  TOP w0.508: F2.1 128.12,217.04 127.1,216.03 122.78,216.03 QN10.D
N23543471: length 1.4
  TOP w0.508: 109.7,47.88 C537.2
N23749903: length 1.7
  TOP w0.203: U28.10 60.43,124.98 60.19,125.22
  TOP w0.635: R317.1 59.58,125.22 60.19,125.22
N23749907: length 1.4
  TOP w0.635: C353.2 58.1,125.84 R317.2
N23749919:
  vias: v1(60.15,127.25) v1(60.81,128.12) v1(60.78,126.75) v1(64.44,132.89) v1(64.41,131.5) v1(64.41,130.07)
N23749953: length 7.2
  TOP w0.203: U28.12 60.5,124.18 60.02,123.7 60.02,123.27 59.61,122.86 v2(59.61,122.66) 59.61,121.9 R332.2
  TOP w0.254: R338.1 R337.2 57.73,121.11 58.82,121.11 R332.2
N23749979: length 15.3
  TOP w0.152: R315.2 v1(64.16,126.97) C352.1 ; R338.2 56.06,119.33 v1(55.52,119.33)
  BOTTOM w0.152: v1(55.52,119.33) 56.49,119.33 v2(58.37,121.21) 58.95,121.79 61.01,121.79 64.16,124.94 v1(64.16,126.97)
N23750037: length 1.3
  TOP w0.254: U28.1 61.91,121.83 61.75,121.67
  vias: v2(60.32,117.78)
N23750263: length 3.6
  TOP w0.102: R330.2 v2(65.74,121.06)
  TOP w0.203: U28.3 64.68,123.38 65.74,122.32 R330.2
N23750267: length 30.8
  TOP w0.203: U28.11 60.34,124.58 60.1,124.33
  TOP w0.254: v1(55.19,118.41) 55.19,117.35 55.7,116.84 55.7,115.9 57.99,113.61 60.66,113.61 66.69,119.65 R330.1 R323.2
  TOP w0.305: 60.1,124.33 59.46,123.7 C356.1
  TOP w0.381: C356.1 59.16,123.7 v1(58.45,122.99)
  BOTTOM w0.254: v1(58.45,122.99) 58.45,122.63 56.62,120.8 v2(56.51,120.8) 55.42,120.8 54.97,120.35 54.97,118.64 v1(55.19,118.41)
N23754361: length 2.3
  TOP w0.254: R327.2 R331.1 R332.1
N23886367: length 4.3
  TOP w0.102: U41.4 50.15,20.03 v2(48.87,21.31) 48.87,21.79 48.15,22.51 R723.1
N24049205: length 9.3
  TOP w0.203: U19.32 161.16,211.6 161.01,211.46 160.25,211.46 159.99,211.2 159.41,211.2
  TOP w0.508: 159.41,211.2 157.1,211.2 155.57,209.68 C133.2 155.55,209.49 R167.1
N24049230: length 6.7
  TOP w0.152: 172.82,215.26 172.54,215.26 172.06,214.78 170.69,214.78 170,214.1 168.71,214.1 168.21,213.6 U19.13 ; 172.82,215.26 172.93,215.37 R117.1 ; 172.82,215.26 C94.2
N24049234: length 4
  TOP w0.203: C166.1 166.6,206.91 166.27,207.23 U19.49
  TOP w0.254: R178.2 C166.1
N24049240: length 2.3
  TOP w0.508: R131.2 155.93,214 C104.1
N24049248: length 11.4
  TOP w0.203: U19.25 163.07,214.47 162.15,215.39
  TOP w0.508: 153.9,213.74 154.99,214.83 157.61,214.83 v2(158.75,215.98) 159.16,216.38 161.16,216.38 162.15,215.39
N24049260: length 9.1
  TOP w0.203: 160.5,213.11 160.86,213.11 161.16,212.8 U19.29
  TOP w0.508: 160.5,213.11 156.82,213.11 156.31,212.6 155.04,212.6 153.9,211.46
N24049270: length 2.5
  TOP w0.508: C125.1 156.82,212.09 156.18,211.46 R145.2
N24049276: length 1.7
  TOP w0.508: C137.1 157.45,208.76 R170.2
N24049291: length 3.8
  TOP w0.203: U19.37 161.75,209.6 160.76,208.61 160.76,208.53
  TOP w0.508: 160.76,208.53 159.87,207.65 159.23,207.65
N24049344: length 96
  TOP w0.254: RT2.1 122.88,181.79 v1(122.75,181.67) ; v1(169.9,217.73) R95.1
  BOTTOM w0.203: v1(169.9,217.73) v2(169.32,218.31) 168.78,218.85 163.67,218.85 163.11,219.41 160.44,219.41 158.53,217.5 155.37,217.5 154.08,216.2 148.95,216.2 144.48,211.73 131.81,211.73 123.2,203.12 119.46,203.12 118.82,202.49 118.82,201.3 117.68,200.15 114.74,200.15 111.71,197.13 111.71,191.54 111.43,191.26 111.43,184.24 113.17,182.5 121.92,182.5 v1(122.75,181.67)
N24049350: length 9.3
  TOP w0.203: R94.1 168.68,217.83 167.23,216.38 166.98,216.38 165.47,214.88 U19.19
  TOP w0.254: R94.1 168.07,219.08 v2(168.07,220.42) 168.07,220.5 168.59,221.01 C52.2
N24049369: length 1.8
  TOP w0.254: R46.1 169.01,223.04 C52.1
N24049420: length 1.1
  TOP w0.152: R116.2 172.82,216.33 R117.2
N24049428: length 67.4
  TOP w0.254: RT1.2 v1(119.74,200.88) ; v1(174.93,215.57) 175.08,215.72 176.04,215.72 R121.2 R122.2
  BOTTOM w0.254: v1(174.93,215.57) 174.35,214.99 173.08,214.99 172.34,214.25 170.59,214.25 169.11,215.72 162.89,215.72 162.1,216.51 155.52,216.51 154.43,215.42 149.22,215.42 144.81,211 132.18,211 123.04,201.85 121.28,201.85 v2(120.73,201.3) 120.31,200.88 v1(119.74,200.88)
N24049447: length 8.6
  TOP w0.203: R121.1 175.44,214.6 172.31,214.6 172.16,214.45 170.79,214.45 170.13,213.79 168.88,213.79 168.29,213.2 U19.12
N24049451: length 2.4
  TOP w0.102: R175.2 177.54,207.04 v2(178.38,206.2)
  TOP w0.254: R166.2 R175.2
N24049453: length 10.6
  TOP w0.102: R175.1 176.61,207.12 v2(176.61,206.15)
  TOP w0.203: C149.2 174.82,207.77 171.68,207.77 170.66,208.79 169.24,208.79 168.43,209.6 U19.3
  TOP w0.254: C149.2 R175.1
N24049485: length 86.7
  TOP w0.152: v1(180.62,202.31) 180.77,202.46 180.77,204.32 179.63,205.46 176.35,205.46 175.74,206.07 173.03,206.07 R174.2
  TOP w0.254: RT3.2 191.9,147.83 v1(192.38,147.83) ; R174.2 171.58,207.14 170.44,208.28 R165.2
  BOTTOM w0.152: v1(192.38,147.83) 192.38,148.08 195.68,151.38 195.68,184.05 191.26,188.47 v2(189.28,188.47) 178.54,188.47 177.95,189.05 177.95,199.25 180.62,201.92 v1(180.62,202.31)
N24049503: length 1.8
  TOP w0.203: U19.2 168.29,209.2 169.21,208.28 R165.1
N24049550: length 105.1
  TOP w0.152: RT4.1 171.81,147.64 171.8,147.65 171.86,147.65 v1(171.96,147.55)
  TOP w0.254: v1(179.07,202.46) 179.07,202.11 176.2,199.24 173.77,199.24 R210.1
  BOTTOM w0.152: v1(171.96,147.55) 172.24,147.27 172.49,147.27 173.2,147.98 181.71,147.98 181.99,148.26 185.95,148.26 187.3,146.91 193.83,146.91 196.34,149.43 196.34,201.02 195.66,201.7 188.59,201.7 187.43,202.87 182.82,202.87 182.39,203.3 179.91,203.3 v2(179.65,203.05) v1(179.07,202.46)
N24049562: length 1.2
  TOP w0.254: C166.2 166.63,204.47 R186.2
N24049624: length 11
  TOP w0.203: R135.2 177.46,213.39 175.44,213.39 175.06,213.77 172.62,213.77 172.44,213.59 171.22,213.59 170.56,212.93 169.88,212.93 169.35,212.4 U19.10
N24049675: length 1.1
  TOP w0.254: C184.2 R194.2
N24049677: length 12.2
  TOP w0.203: U19.46 165.07,206.38 163.65,204.95 163.65,204.22 C170.1
  TOP w0.254: R204.2 R193.1 159.91,202.64 160.48,202.64 160.53,202.69 161.49,202.69 R194.1 163.14,202.18 R201.2 C170.1
N24049689: length 1.5
  TOP w0.254: R204.1 158.5,200.85 C187.2
N24049710: length 8
  TOP w0.203: U19.23 163.87,214.69 163.19,215.37 163.19,217.17
  TOP w0.254: 163.19,217.17 163.19,218.89 R92.2 C72.2 C73.2
N24049720: length 12.1
  TOP w0.203: U19.22 164.27,214.76
  TOP w0.254: R45.2 165.58,223.04 165.58,222.03 166.09,221.52 R67.2 R66.2 v2(164.95,220.4) 165.46,219.89 165.46,219.06 C73.1 164.31,217.91 164.31,216.9 R111.1 163.8,215.52 164.27,215.05 164.27,214.76
N24049728: length 1.1
  TOP w0.254: C72.1 R111.2
N24049736: length 2.4
  TOP w0.203: 164.67,214.88 U19.21
  TOP w0.254: 164.67,214.88 164.67,216.19 R110.2
N24049738: length 1.7
  TOP w0.254: C644.2 166.71,223.03 166.71,222.97 R67.1
N24049758: length 1.2
  TOP w0.254: R66.1 C37.2
N24049870: length 1.1
  TOP w0.254: R193.2 C175.1
N24049911: length 1.6
  TOP w0.254: C71.2 R110.1
N24049917: length 4.1
  TOP w0.203: R182.1 164.24,205.03 165.47,206.27 U19.47
N24049919: length 1.8
  TOP w0.254: C181.2 164.03,202.38 164.03,203.56 R182.2
N24053357: length 2.3
  TOP w0.102: R91.2 176.14,219.6 v2(176.45,219.91)
  TOP w0.254: R73.1 175.49,220.53 R91.2
N24054034: length 2.6
  TOP w0.102: R164.1 v2(184.65,208.31)
  TOP w0.254: R164.1 183.43,208.31 R163.2
N24054595: length 1.8
  TOP w0.254: U24.2 189.46,175.01 R272.1
N24054604: length 3.4
  TOP w0.102: R115.1 184.63,216.95 v2(184.63,217.37)
  TOP w0.254: R114.2 183.43,215.93 R115.1
N24061533: length 1.1
  TOP w0.254: R209.1 R208.1
N24061699: length 1.1
  TOP w0.254: R211.2 R212.1
N24062865: length 1.8
  TOP w0.254: U27.2 190.86,139.58 R301.1
N24625806: length 2.4
  TOP w0.102: D25.3 189.42,48.17 188.89,48.7 QN40.1
N24707255: length 1.6
  TOP w0.508: Q44.B 161.04,219.46 R343.1
N24718617: length 1.6
  TOP w0.635: 179.3,161.67 179.77,162.15 C265.2

## Copper pours and planes (outline as drawn)
+1V05_SA on TOP (solid shape): outline of 249 points within 103.78,168.2 127.63,187.15
+1V05_SA on TOP (solid shape): outline of 232 points within 108.66,145.42 112.62,154.94
+1V05_SA on BOTTOM (solid shape): outline of 907 points within 103.96,146.15 127.63,187.15
+1V05_SA on PWR (solid shape): outline of 1127 points within 103.78,146.18 127.99,187.15
+1V8_AVCC on TOP (solid shape): 196.39,229.95 196.39,229.44 196.21,229.26 193.01,229.26 192.15,228.4 191.54,228.4 191.54,228.4 190.3,228.4 190.27,228.42 190.27,228.93 190.32,228.98 191.21,228.98 192.35,230.12 196.21,230.12
+1V8_VDDC on TOP (solid shape): 184.51,231.24 184.51,229.19 184.51,229.19 184.51,229.11 185.42,228.19 186.16,228.19 186.21,228.14 186.21,227.63 186.16,227.58 185.01,227.58 184.76,227.33 183.87,227.33 183.58,227.62 183.58,231.31 183.79,231.52 184.23,231.52
+3V3_IVDD on TOP (solid shape): 194.31,232.28 194.31,231.57 193.83,231.09 193.83,230.4 192.3,230.4 191.08,229.18 190.32,229.18 190.27,229.24 190.27,229.74 190.32,229.79 190.78,229.79 191.24,230.25 191.24,231.01 191.97,231.75 192.99,231.75 193.65,232.41 194.18,232.41
+3VSB on TOP (solid shape): 14.71,189.71 14.71,187.22 13.32,185.84 13.32,185.03 12.83,184.54 12.57,184.54 12.56,184.53 11.48,184.53 10.97,185.04 10.97,187.91 11.1,188.04 11.76,188.04 12.08,188.35 12.08,189.13 12.11,189.22 12.12,189.31 12.12,189.33 12.13,189.35 12.78,189.99 14.43,189.99
+3VSB on TOP (solid shape): 71.27,42.99 71.62,42.99 71.62,42.91 71.64,42.82 71.7,42.73 72.56,41.87 75.32,39.12 76.68,39.12 77.31,38.49 77.31,37.9 77.26,37.84 76.48,37.84 76.28,37.64 76.28,37.11 76.23,37.06 75.64,37.06 75.54,37.16 75.54,37.36 74.37,38.53 74.02,38.53 71.31,41.24 71.31,41.97 70.89,42.39 70.82,42.39 70.36,42.85 70.36,43.01 70.48,43.13 71.12,43.13
+3VSB on TOP (solid shape): 154.91,61.21 154.91,60.02 154.07,59.18 149.83,59.18 148.44,57.78 148.44,53.09 148.18,52.83 146.81,52.83 146.79,52.84 146.77,52.85 146.46,52.98 146.14,52.85 146.12,52.84 146.1,52.83 145.29,52.83 145.16,52.96 144.81,53.11 144.45,52.96 144.32,52.83 144.12,52.83 143.26,53.7 143.26,57.2 143.57,57.52 144.41,57.52 144.98,58.09 144.98,60.86 145.16,61.04 148.21,61.04 148.41,61.24 151.84,61.24 152.45,61.85 154.28,61.85
+3VSB on BOTTOM (solid shape): outline of 503 points within 13.64,186.89 21.29,194.64
+3VSB on PWR (solid shape): outline of 10001 points within 45.69,18.67 148.31,69.98
+5V_DUAL on TOP (solid shape): 143,65.43 143,64.19 142.7,63.88 142.7,63.53 142.47,63.3 141.83,63.3 140.82,64.31 140.13,64.31 139.83,64.62 139.83,65.23 140.21,65.61 142.82,65.61
+5V_DUAL on TOP (solid shape): 168.25,77.32 168.25,74.22 170.1,72.36 170.1,68.25 170,68.15 168.27,68.15 168.07,68.35 168.07,69.98 167.02,71.03 165.96,71.03 165.89,71.06 165.86,71.13 165.54,71.51 165.07,71.33 165.06,71.32 165.02,71.3 161.01,71.3 160.81,71.5 160.81,72.92 160.81,72.95 160.78,72.95 160.76,72.97 160.76,74.17 160.81,74.22 160.81,75.06 160.5,75.36 159.82,75.36 158.48,76.7 157.88,76.7 157.81,76.73 157.78,76.81 157.52,77.26 157.02,77.13 157,77.12 156.98,77.11 156,77.11 154.96,76.07 152.02,76.07 150.85,77.24 150.8,77.24 150.79,77.25 150.48,77.34 150.19,77.19 150.01,77.01 149.96,76.77 149.94,76.69 149.86,76.66 149.45,76.66 149.3,76.81 149.3,80.57 149.68,80.95 164.62,80.95
+5V_DUAL on BOTTOM (solid shape): outline of 376 points within 140.89,62.79 165.73,80.31
+5V_DUAL_PFB on TOP (solid shape): 142.95,72.9 144.32,72.9 144.35,72.87 144.35,71.83 142.75,71.83 141.71,70.79 140.79,70.79 139.27,69.27 139.27,64.54 138.99,64.26 136.8,64.26 136.32,64.74 136.32,70.69 138.56,72.92 141.3,72.92 141.55,73.18 142.67,73.18
+5V_HDMI on TOP (solid shape): 155.52,235.51 155.52,229.51 156.31,228.73 156.31,227.48 155.98,227.15 155.5,227.15 154.66,227.99 152.15,227.99 152.04,228.09 152.04,228.78 154.71,231.44 154.71,235.03 154.56,235.18 154,235.18 153.85,235.03 153.85,231.95 153.8,231.9 153.62,231.9 153.57,231.95 153.57,235.74 153.8,235.97 155.07,235.97
+5VDUAL_1P0A on TOP (solid shape): 130.48,64.77 130.48,62.71 131.6,61.59 131.6,59.72 132.05,59.26 133.58,59.26 134.67,58.17 136.37,58.17 136.75,57.78 136.75,55.25 136.37,54.86 134.06,54.86 132.85,56.07 132.5,56.07 132.18,56.19 131.86,56.07 130.7,56.07 130.68,56.08 130.44,56.08 130.11,56.21 129.77,56.08 128.8,56.08 128.57,56.31 128.57,60.73 127.69,61.62 127.69,64.59 128.12,65.02 130.23,65.02
+5VSB on TOP (solid shape): 147.42,49.15 147.42,47.62 147.04,47.24 143.31,47.24 143.03,47.52 143.03,48.61 143.7,49.28 144.58,49.28 144.58,49.28 147.29,49.28
+5VSB on TOP (solid shape): 11.56,67.92 11.56,66.24 11.23,65.91 8.89,65.91 8.43,65.46 6.6,65.46 6.45,65.61 6.45,66.17 6.86,66.57 7.29,66.57 7.52,66.8 7.52,67.92 7.87,68.28 11.2,68.28
+5VSB on TOP (solid shape): 110.69,212.24 110.69,211.35 110.36,211.02 109.63,211.02 108.58,209.98 106.32,209.98 105.97,210.34 105.97,210.69 106.17,210.9 106.76,210.9 107.71,211.85 109.26,211.85 109.8,212.39 110.54,212.39
+5VSB on TOP (solid shape): 75.77,202.82 75.77,202.46 75.72,202.41 74.32,202.41 74.18,202.27 74.18,201.64 73.18,200.63 72.14,200.63 71.88,200.38 71.88,199.06 72.54,198.4 72.54,198.02 72.21,197.69 70.64,197.69 69.72,196.77 69.11,196.77 68.94,196.95 68.94,200.23 70.89,202.18 72.67,202.18 73.36,202.87 75.72,202.87
+5VSB on TOP (solid shape): 13.89,23.57 17.7,23.57 18.34,22.94 19.58,22.94 19.71,23.06 19.71,23.16 19.74,23.18 19.74,24.46 20.19,24.46 20.19,22.55 20.19,22.48 20.19,22.28 20.19,22.05 20.02,21.87 17.48,21.87 17.44,21.91 15.75,21.91 15.7,21.94 15.7,21.95 15.32,22.18 14.94,21.95 14.93,21.94 14.88,21.91 11.11,21.91 9.98,23.04 9.98,24.49 12.37,24.49 12.38,24.5 12.97,24.5
+5VSB on BOTTOM (solid shape): 13.69,65.68 13.69,60.83 13.31,60.45 11.79,60.45 11.6,60.64 11.6,65.37 10.34,66.62 10.34,68.02 10.52,68.2 11.18,68.2
+5VSB on PWR (solid shape): outline of 3623 points within 3.53,4.44 169.9,49.15
+12V on TOP (solid shape): 139.9,35.23 139.9,31.27 139.57,30.94 133.02,30.94 132.69,31.27 132.69,35.56 133.32,36.19 138.94,36.19
+12V on TOP (solid shape): 175.23,31.5 175.23,22.91 174.8,22.48 170.71,22.48 170.41,22.78 170.41,31.27 171.02,31.88 174.85,31.88
+12V on TOP (solid shape): 183.06,70.26 183.06,66.78 182.63,66.34 181.23,66.34 180.72,66.85 180.72,70.38 181.03,70.69 182.63,70.69
+12V on TOP (solid shape): 57.94,115.42 59.08,115.42 59.33,115.16 59.33,114.2 59.14,114.01 57.95,114.01 56.18,115.78 56.17,115.81 56.18,115.85 56.62,116.28 57.07,116.28
+12V on TOP (solid shape): 33.78,1.5 34.53,1.5 34.54,1.48 36.16,1.22 37.78,1.48 37.85,1.5 38.59,1.5 39.47,2.39 40.77,2.39 41.58,3.2 43.71,3.2 44.12,2.79 44.12,0.71 43.94,0.53 30.28,0.53 29.82,0.99 29.82,2.46 30.84,3.48 31.8,3.48
+12V on TOP (solid shape): outline of 84 points within 182.5,102.62 193.34,110.01
+12V on TOP (solid shape): outline of 141 points within 13.64,195.58 41.55,201.19
+12V on BOTTOM (solid shape): 17.97,199.01 18,198.99 18.02,198.96 18.02,197.73 19.34,197.73 19.34,198.96 19.35,198.99 19.39,199.01 20.93,199.01 21.18,198.75 21.18,196.72 20.93,196.47 20.04,196.47 19.15,195.58 14.83,195.58 14.8,195.61 14.8,195.62 14.65,195.86 14.4,196.02 14.39,196.02 13.64,196.77 13.64,198.18 14.47,199.01
+12V on BOTTOM (solid shape): outline of 846 points within 132.69,22.48 172.57,36.19
+12V on PWR (solid shape): outline of 9302 points within 0.51,0.51 199.49,220.6
+12V on GND (solid shape): outline of 1868 points within 0.51,0.51 178.54,184.15
+12V_4P on TOP (solid shape): 195.55,200.63 195.55,196.37 195.15,195.96 186.79,195.96 186.16,195.33 186.16,194.44 185.78,194.06 179.04,194.06 178.66,194.44 178.66,197.49 180.57,199.39 182.73,199.39 184.25,200.91 195.28,200.91
+12V_4P on BOTTOM (solid shape): 195.55,200.61 195.55,196.44 195.07,195.96 186.79,195.96 186.16,195.33 186.16,194.31 185.9,194.06 179.04,194.06 178.66,194.44 178.66,197.99 180.57,199.9 183.24,199.9 184.25,200.91 195.25,200.91
+12V_4P on PWR (solid shape): 195.94,200.76 195.94,196.12 195.78,195.96 186.76,195.96 186.16,195.36 186.16,192.69 186.02,192.55 185.51,193.17 185.03,192.53 179.33,192.53 178.92,192.94 178.92,197.71 180.6,199.39 182.76,199.39 184.28,200.91 195.78,200.91
+V1P0A on TOP (solid shape): 40.86,61.94 40.86,61.35 40.58,61.07 37.81,61.07 36.7,62.18 36.7,62.46 36.83,62.59 40.21,62.59
+V1P0A on TOP (solid shape): 106.02,57.43 106.02,52.17 105.79,51.94 100.05,51.94 98.7,53.29 97.03,53.29 96.55,52.81 96.55,51.21 96.09,50.75 94.03,50.75 93.47,51.31 93.47,57.07 93.7,57.3 94.41,57.3 94.54,57.18 99.57,57.18 100.81,58.42 105.03,58.42
+V1P0A on TOP (solid shape): 72.67,152.1 72.67,151.41 72.28,151.02 72.28,150.5 71.72,149.94 71.32,149.94 71.09,149.71 71.09,149.02 70.99,148.92 70.99,147.68 70.97,147.65 70.26,147.65 70.22,147.67 70.21,147.7 70.21,147.93 69.82,148.31 69.82,150.8 70.43,151.41 71.3,151.41 71.65,151.76 71.65,152.27 71.86,152.48 72.29,152.48
+V1P0A on BOTTOM (solid shape): 106.02,57.4 106.02,52.17 105.79,51.94 101.83,51.94 101.04,52.73 101.04,58.14 101.32,58.42 105,58.42
+V1P0A on BOTTOM (solid shape): 65.05,58.04 65.05,56.46 64.9,56.31 63.92,56.31 63.82,56.21 63.82,55.56 63.63,55.37 63.61,55.36 63.59,55.35 63.39,55.35 63.14,55.6 63.14,55.63 63.07,55.88 62.86,56.04 62.79,56.06 62.73,56.06 61,56.06 60.91,56.16 60.9,56.18 60.89,56.19 60.89,56.58 61.46,57.14 61.48,57.15 61.5,57.14 61.83,57.18 62.03,57.43 62.05,57.46 62.08,57.47 63.37,57.47 63.59,57.69 63.72,57.69 64.1,58.07 65.02,58.07
+V1P0A on BOTTOM (solid shape): 63,55.2 63.02,55.2 63.04,55.18 63.13,55.09 63.14,55.06 63.13,55.04 63.17,54.66 63.51,54.48 63.56,54.48 63.6,54.49 63.69,54.47 63.73,54.39 63.73,52.7 62.59,51.56 60.25,51.56 59.97,51.84 59.97,52.73 59.66,53.04 59.64,53.04 59.56,53.11 58.71,53.11 58.56,53.26 58.56,53.48 58.77,53.69 59.65,53.69 59.66,53.69 61.56,53.69 61.59,53.72 61.64,53.79 61.71,53.78 61.86,53.71 62.03,53.71 62.1,53.73 62.16,53.76 62.25,53.83 62.32,53.93 62.36,54.12 62.31,54.31 62.27,54.36 62.14,54.47 61.99,54.51 61.89,54.51 61.86,54.51 61.84,54.52 61.67,54.7 61.65,54.72 61.65,54.74 61.65,55.05 61.8,55.2
+V1P0A on BOTTOM (solid shape): 65.13,55.88 65.13,51.97 65.12,51.94 64.9,51.7 64.82,51.4 64.82,51.02 64.9,50.72 65.12,50.47 65.13,50.45 65.13,50.29 64.49,49.66 64.33,49.66 64.26,49.68 64.23,49.75 63.85,50.12 63.47,49.75 63.44,49.68 63.37,49.66 63.24,49.66 63.17,49.69 63.14,49.76 62.76,50.14 62.38,49.76 62.35,49.69 62.27,49.66 61.27,49.66 60.66,50.27 60.64,50.27 60.49,50.37 60.33,50.4 60.31,50.41 60.05,50.67 60.05,51.18 60.17,51.31 62.29,51.31 62.38,51.26 62.38,51.16 62.85,50.65 62.92,51.34 62.87,51.41 62.9,51.5 63.98,52.58 63.98,52.89 64.03,52.98 64.13,52.98 64.36,52.96 64.56,53.07 64.59,53.57 64.11,53.68 64.02,53.7 63.98,53.78 63.98,54.44 64.03,54.53 64.13,54.53 64.66,54.88 64.13,55.23 64.03,55.24 63.98,55.33 63.98,55.88 64.11,56.01 65,56.01
+V1P0A on PWR (solid shape): outline of 9692 points within 35.28,42.8 106.02,72.8
+V1P0A_VCCAMPHYPLL on TOP (solid shape): outline of 150 points within 70.57,63.29 76.17,70.8
+V1P0A_VCCAPLL on TOP (solid shape): 53.02,50.67 53.05,50.6 53.02,50.53 52.93,50.15 53.21,49.89 53.25,49.88 53.25,49.79 53.25,49.78 53.22,49.65 53.25,49.52 53.25,49.51 53.25,49.28 53.33,49.2 53.33,48.87 53.23,48.75 52.95,48.75 52.92,48.77 52.87,48.8 52.79,48.87 52.79,49.32 52.55,49.56 52.55,50.23 52.56,50.4 52.55,50.44 52.55,50.82 52.65,50.91 52.78,50.91
+V1P0A_VCCST on TOP (solid shape): 74.83,152.27 74.83,149.63 73.96,148.77 73.96,147.88 73.74,147.65 72.24,147.65 72.21,147.68 72.21,149.05 72.59,149.43 73.18,149.43 73.89,150.14 73.89,151.28 73.71,151.46 73.18,151.46 73.05,151.59 73.05,152.4 73.23,152.58 74.52,152.58
+V3P3_WLAN on TOP (solid shape): 48.18,121.77 48.18,120.52 49.42,119.29 49.42,118.87 49.86,118.43 50.28,118.43 51.99,116.71 53.39,116.71 56.06,114.05 56.06,112.22 55.85,112.01 53.06,112.01 52.68,112.4 50.11,112.4 50.05,112.46 50.05,116.55 48.31,118.29 48.1,118.29 48.02,118.32 48,118.4 47.19,119.28 46.38,118.4 46.35,118.32 46.27,118.29 46.25,118.29 43.74,115.77 36.63,115.77 36.12,115.27 29.31,115.27 27.79,116.79 27.79,117.56 27.79,117.58 27.81,117.6 28.25,118.47 27.81,119.33 27.79,119.35 27.79,119.37 27.79,120.38 27.79,120.4 27.81,120.42 27.81,122 28.28,122.46 28.3,122.47 28.31,122.48 28.6,122.48 28.92,122.16 28.93,122.08 28.93,121.66 28.92,121.66 28.92,119.83 28.93,119.83 28.93,119.79 29.41,119.3 29.41,117.98 30.25,117.14 34.42,117.14 35.75,118.48 42.23,118.48 43.13,119.38 45.11,119.38 45.57,119.84 45.57,122.71 45.87,123.01 46.94,123.01
+V3P3_WLAN on BOTTOM (solid shape): 28.28,123.51 28.28,122.64 28.88,122.05 28.88,121.36 28.69,121.17 28.16,121.17 27.43,121.89 27.43,123.52 27.61,123.7 28.09,123.7
+VCC on TOP (solid shape): 136.14,60.5 136.14,58.75 135.92,58.52 134.8,58.52 134.1,59.22 134.1,60.67 134.26,60.83 135.81,60.83
+VCC on TOP (solid shape): 19.51,24.74 19.51,24.43 19.52,24.43 19.53,24.41 19.53,23.27 19.51,23.24 18.34,23.24 18.16,23.42 18.16,24.82 18.29,24.94 19.3,24.94
+VCC on TOP (solid shape): 163.93,223.93 163.93,222 163.3,221.36 161.9,221.36 161.14,220.6 159.61,220.6 159.23,220.98 159.23,221.49 160.76,223.01 160.76,223.93 161.11,224.28 163.58,224.28
+VCC on TOP (solid shape): 35.53,61.54 35.53,58.93 36.68,57.78 36.68,57.15 36.3,56.77 34.09,56.77 33.59,56.26 31.85,56.26 31.32,56.79 31.32,61.57 31.55,61.8 35.28,61.8
+VCC on TOP (solid shape): 160.53,74.02 160.56,74 160.58,73.96 160.58,72.95 160.56,72.95 160.56,72.44 160.58,72.44 160.58,70.79 160.4,70.61 159.64,70.61 159.33,70.92 159.33,73.69 159.66,74.02
+VCC on TOP (solid shape): 15.16,66.22 15.16,63.32 14.96,63.12 14.2,63.12 13.82,63.5 13.82,63.91 13.74,63.98 13.74,64.08 13.67,64.16 12.14,64.16 12.06,64.24 12.06,64.82 12.12,64.87 13.69,64.87 13.89,65.07 13.89,66.27 14.07,66.45 14.94,66.45
+VCC on TOP (solid shape): 75.74,204.55 75.74,203.07 75.72,203.05 73.18,203.05 72.66,202.53 71.18,202.53 70.94,202.77 70.94,203.66 71.39,204.1 71.41,204.12 71.44,204.12 71.74,204.08 72.04,204.17 72.49,204.17 73,204.67 75.62,204.67
+VCC on TOP (solid shape): 101.4,216.97 101.4,216 101.52,215.87 101.52,213.69 102.04,213.17 102.04,213.14 102.11,213.08 103.72,213.08 103.78,213.02 103.78,212.55 103.66,212.42 101.22,212.42 100.65,211.85 100.65,210.79 100.84,210.6 100.84,210.39 100.56,210.11 99.9,210.11 99.42,210.59 99.42,212.06 100.18,212.83 100.18,214.55 100.18,214.55 100.18,216.44 100.84,217.09 101.27,217.09
+VCC on TOP (solid shape): 130.66,50.67 130.66,46.1 131.7,45.06 132.71,45.06 133.26,45.61 134.71,45.61 134.72,45.62 134.82,45.62 135.61,44.83 135.61,44.07 136.37,43.31 137.33,43.31 137.67,43.17 138.02,43.31 141.86,43.31 143.74,41.43 143.74,39.88 143.23,39.37 133.83,39.37 133.82,39.38 133.26,39.38 130.66,41.99 128.4,41.99 127.79,42.6 127.79,50.42 128.17,50.8 130.53,50.8
+VCC on TOP (solid shape): outline of 84 points within 153.52,33.73 164.74,38.89
+VCC on BOTTOM (solid shape): outline of 143 points within 127.86,49.33 137.13,60.58
+VCC on BOTTOM (solid shape): outline of 959 points within 132.92,34.06 168.73,73.91
+VCC on PWR (solid shape): outline of 22173 points within 3.53,7.59 163.93,224.28
+VCC3 on TOP (solid shape): 108.94,23.75 108.94,22.35 108.64,22.05 106.1,22.05 105.99,22.15 105.56,22.15 105.46,22.25 105.46,22.68 106.15,23.37 107.54,23.37 108.05,23.88 108.81,23.88
+VCC3 on TOP (solid shape): 108.94,7.44 108.94,5.08 108.81,4.95 106.32,4.95 106.24,5.04 106.24,5.83 106.25,5.84 107.92,5.84 108.05,5.97 108.05,7.42 108.18,7.54 108.84,7.54
+VCC3 on TOP (solid shape): 181.58,41.78 181.58,40.26 181.2,39.88 180.19,39.88 178.41,38.1 178.41,31.52 178,31.12 176.25,31.12 174.66,32.7 170.6,32.7 170.28,33.02 170.28,37.34 170.79,37.85 173.84,37.85 174.47,38.48 174.47,41.66 174.98,42.16 181.2,42.16
+VCC3 on TOP (solid shape): 115.16,22.22 115.16,14.99 110.59,10.41 110.59,8.95 109.93,8.29 107.86,8.29 107.7,8.46 107.7,9.02 108.18,9.5 108.18,12.45 111.99,16.26 111.99,20.45 112.03,20.54 112.12,20.55 112.7,20.96 112.12,21.36 112.03,21.37 111.99,21.46 111.99,22.61 112.5,23.11 114.27,23.11
+VCC3 on TOP (solid shape): outline of 349 points within 42.04,73.33 113.44,90.07
+VCC3 on TOP (solid shape): outline of 743 points within 6.05,186.36 43.13,192.94
+VCC3 on BOTTOM (solid shape): 23.96,94.35 23.96,89.95 21.56,87.55 15.62,87.55 15.24,87.93 15.24,95.07 15.67,95.5 22.81,95.5
+VCC3 on BOTTOM (solid shape): 74.45,80.47 74.45,76.17 74.22,75.95 67.87,75.95 64.64,79.17 64.64,80.54 64.87,80.77 74.14,80.77
+VCC3 on BOTTOM (solid shape): 93.21,76.89 96.85,76.89 97.05,76.68 97.05,74.47 96.88,74.3 88.85,74.3 88.34,74.8 88.34,76.84 88.54,77.04 93.06,77.04
+VCC3 on BOTTOM (solid shape): 109.93,23.65 109.93,21.59 110.29,21.23 110.29,20.65 110.13,20.5 108.99,20.5 108.79,20.7 108.79,21.44 107.9,22.33 107.9,23.72 108.05,23.88 109.7,23.88
+VCC3 on BOTTOM (solid shape): 110.08,9.19 110.08,8 109.83,7.75 109.83,6.1 109.6,5.87 108.38,5.87 107.52,6.73 107.52,9.02 107.95,9.45 109.83,9.45
+VCC3 on BOTTOM (solid shape): outline of 92 points within 105.21,73.28 113.44,78.92
+VCC3 on PWR (solid shape): outline of 6991 points within 3.53,72.01 58.39,196.09
+VCC3 on PWR (solid shape): outline of 19178 points within 22.33,22.35 191.24,131.32
+VCCGT on TOP (solid shape): outline of 2853 points within 131.32,130.68 178.54,164.97
+VCCGT on BOTTOM (solid shape): outline of 1997 points within 131.32,131.32 177.39,164.97
+VCCIO on TOP (solid shape): 72.92,136.07 72.92,133.38 72.67,133.12 72.03,133.12 68.81,129.9 68.81,126.39 67.31,124.89 63.4,124.89 63.3,124.99 63.3,126.21 63.55,126.47 65.23,126.47 65.51,126.75 65.51,127.28 65.2,127.58 65.2,135.61 65.33,135.74 65.53,135.74 65.63,135.84 65.63,136.22 65.76,136.35 66.37,136.35 66.73,136.7 72.29,136.7
+VCCIO on TOP (solid shape): outline of 282 points within 110.82,142.29 116.05,154.74
+VCCIO on BOTTOM (solid shape): outline of 509 points within 65.2,130.07 128.12,148.78
+VCCIO on PWR (solid shape): 72.22,136.53 72.24,136.52 72.26,136.51 72.62,136.05 72.62,133.71 68.32,129.41 65.48,129.41 65.13,129.77 65.13,135.91 65.74,136.53
+VCCPFUSE_3P3 on TOP (solid shape): 51.76,43.65 51.82,43.65 51.84,43.65 51.86,43.64 52,43.5 52.01,43.47 52,43.46 52.04,43.18 52.26,43 52.28,42.98 52.29,42.95 52.29,42.81 50.37,40.89 50.37,39.3 48.11,37.03 46.38,37.03 46.1,37.31 46.1,38.46 47.68,40.03 49.02,40.03 49.26,40.27 49.47,40.42 49.62,40.63 49.89,40.89 49.89,41.54 50.99,42.64 51.01,42.64 51.03,42.64 51.17,42.63 51.3,42.7 51.38,42.86 51.36,43.03 51.36,43.1 51.4,43.16 51.49,43.26 51.52,43.39 51.52,43.4 51.53,43.43 51.53,43.53 51.66,43.66
+VCCPGPPD on TOP (solid shape): 72.74,45.03 72.76,45.03 72.77,45.02 73.49,44.3 74.64,43.15 74.64,42.62 75.3,41.96 76.3,41.96 79.96,38.3 80.26,38.3 80.47,38.1 80.47,36.73 80.31,36.58 79.6,36.58 75.87,40.31 74.94,40.31 73.54,41.71 73.54,42.73 72.66,43.61 72.28,43.61 72.23,43.66 71.99,43.66 71.94,43.67 71.9,43.67 71.68,43.89 71.68,44.04 71.8,44.16 72.27,44.34 72.16,44.83 72.14,44.86 72.14,44.9 72.16,44.93 72.17,44.96 72.22,45.02 72.3,45.02 72.39,45.01 72.49,45.03 72.49,45.03
+VIN_95V on TOP (solid shape): 124.23,62.92 125.73,62.92 128.22,60.43 128.22,56.31 128.12,56.21 128.1,56.21 128.09,56.21 127.94,56.2 127.8,56.16 126.8,56.16 126.57,56.39 126.57,58.22 126.34,58.45 125.96,58.45 125.65,58.75 125.65,59.74 125.09,60.3 124.62,60.3 124.61,60.3 124.43,60.34 124.26,60.3 124.25,60.3 121.49,60.3 118.92,57.73 113.28,57.73 112.85,58.17 112.85,65.28 113.18,65.61 121.54,65.61
+VIN_95V on BOTTOM (solid shape): 123.14,64.01 123.14,60.6 122.83,60.3 121.49,60.3 118.92,57.73 113.28,57.73 112.85,58.17 112.85,65.28 113.18,65.61 121.54,65.61
+VIN_CPU on TOP (solid shape): outline of 619 points within 122.02,121.26 197.61,208.03
+VIN_CPU on BOTTOM (solid shape): 186.16,193.29 186.16,192.02 185.78,191.64 185.01,191.64 184.38,191.01 184.38,189.1 184.25,188.98 178.92,188.98 178.66,189.23 178.66,193.42 178.92,193.68 185.78,193.68
+VIN_CPU on PWR (solid shape): outline of 1044 points within 122.02,130.84 199.49,208.92
+VIN_SA on TOP (solid shape): outline of 429 points within 102.79,197.74 121.26,208.03
+VIN_SA on PWR (solid shape): outline of 382 points within 102.79,197.74 121.26,208.03
GND on TOP (solid shape): 44.81,65.58 44.81,64.44 44.45,64.08 41.27,64.08 41.02,64.34 41.02,66.12 41.71,66.8 43.59,66.8
GND on TOP (solid shape): 60.2,192 60.2,190.32 59.99,190.12 56.78,190.12 55.56,191.34 55.56,191.96 55.75,192.15 60.05,192.15
GND on TOP (solid shape): 101.7,198.5 101.7,194.56 101.57,194.44 98.91,194.44 98.65,194.69 98.65,198.86 99.19,199.39 100.81,199.39
GND on TOP (solid shape): 107.34,180.87 107.34,178.33 107.09,178.08 104.04,178.08 103.78,178.33 103.78,180.75 104.36,181.32 106.9,181.32
GND on TOP (solid shape): 115.16,196.47 115.16,193.42 115.04,193.29 112.37,193.29 112.24,193.42 112.24,196.47 112.37,196.6 115.04,196.6
GND on TOP (solid shape): 119.1,68.58 119.1,66.29 118.72,65.91 114.15,65.91 113.77,66.29 113.77,68.58 114.02,68.83 118.85,68.83
GND on TOP (solid shape): 125.37,152.86 125.37,142.14 125.17,141.94 123.93,141.94 123.65,142.21 123.65,153.01 123.75,153.11 125.12,153.11
GND on TOP (solid shape): 131.72,208.15 131.72,207.11 131.5,206.88 127.86,206.88 127.61,207.14 127.61,208.28 127.74,208.41 131.47,208.41
GND on TOP (solid shape): 132.94,189.23 132.94,185.29 132.82,185.17 130.02,185.17 129.9,185.29 129.9,188.72 131.29,190.12 132.05,190.12
GND on TOP (solid shape): 135.94,70.21 135.94,64.62 135.69,64.36 134.06,64.36 133.63,64.8 133.63,69.9 134.34,70.61 135.53,70.61
GND on TOP (solid shape): 140.56,208.28 140.56,207.01 140.44,206.88 137.52,206.88 137.39,207.01 137.39,208.28 137.52,208.41 140.44,208.41
GND on TOP (solid shape): 144.7,59.99 144.7,58.22 144.48,57.99 143.43,57.99 143.28,58.14 143.28,60.05 143.43,60.2 144.5,60.2
GND on TOP (solid shape): 149.91,66.6 149.91,65.05 149.61,64.74 145.67,64.74 145.36,65.05 145.36,66.45 145.85,66.93 149.58,66.93
GND on TOP (solid shape): 163.32,61.04 163.32,59.49 163.02,59.18 156.29,59.18 156.11,59.36 156.11,61.01 156.39,61.29 163.07,61.29
GND on TOP (solid shape): 174.85,191.64 174.85,189.99 174.73,189.87 171.42,189.87 171.3,189.99 171.3,191.64 171.42,191.77 174.73,191.77
GND on TOP (solid shape): 178.84,63.22 178.84,60.68 178.71,60.55 177.09,60.55 176.86,60.78 176.86,63.37 176.96,63.47 178.59,63.47
GND on TOP (solid shape): 179.17,163.32 179.17,162.94 178.28,162.05 174.35,162.05 174.22,162.18 174.22,164.85 174.35,164.97 177.52,164.97
GND on TOP (solid shape): 179.17,147.32 179.17,145.29 178.41,144.53 174.35,144.53 174.22,144.65 174.22,147.19 174.47,147.45 179.04,147.45
GND on TOP (solid shape): 185.52,182.37 185.52,180.09 185.39,179.96 182.35,179.96 182.22,180.09 182.22,182.75 182.35,182.88 185.01,182.88
GND on TOP (solid shape): 185.65,164.85 185.65,162.18 185.52,162.05 182.47,162.05 182.35,162.18 182.35,164.85 182.47,164.97 185.52,164.97
GND on TOP (solid shape): 185.65,146.94 185.65,144.65 185.52,144.53 182.47,144.53 182.35,144.65 182.35,147.32 182.47,147.45 185.14,147.45
GND on TOP (solid shape): 195.53,194.97 195.53,190.75 195.15,190.37 187.05,190.37 186.92,190.5 186.92,195.07 187.05,195.2 195.3,195.2
GND on TOP (solid shape): 197.03,137.01 197.03,132.79 196.75,132.51 195.66,132.51 195.4,132.77 195.4,136.93 195.66,137.19 196.85,137.19
GND on TOP (solid shape): 131.06,153.16 131.06,142.06 130.86,141.86 128.17,141.86 127.97,142.06 127.97,153.06 128.24,153.34 130.89,153.34
GND on TOP (solid shape): 8.59,164.31 10.85,164.31 11.02,164.13 11.02,162.66 10.85,162.48 6.86,162.48 6.07,163.27 6.07,165.25 6.2,165.38 7.52,165.38
GND on TOP (solid shape): 11,158.55 11,155.5 10.74,155.24 8.33,155.24 8.08,155.5 8.08,158.09 8.43,158.45 8.74,158.45 9.07,158.78 10.77,158.78
GND on TOP (solid shape): 36.63,111.56 36.63,109.22 37.9,107.95 37.9,105.59 37.69,105.38 37.13,105.38 35.28,107.24 35.28,111.66 35.43,111.81 36.37,111.81
GND on TOP (solid shape): 52.48,111.76 56.21,111.76 56.36,111.61 56.36,109.5 53.76,106.9 53,106.9 50.04,109.85 50.04,112.12 50.11,112.19 52.04,112.19
GND on TOP (solid shape): 72.75,138.4 72.75,137.16 72.59,137.01 66.57,137.01 66.22,136.65 65.56,136.65 65.35,136.86 65.35,137.59 67.51,139.75 71.4,139.75
GND on TOP (solid shape): 117.12,49.28 117.12,46.66 116.89,46.43 113.41,46.43 112.7,47.14 112.06,47.14 111.76,47.45 111.76,48.01 113.11,49.35 117.04,49.35
GND on TOP (solid shape): 141.27,69.47 141.27,68.96 141.1,68.78 141.1,66.37 140.77,66.04 139.98,66.04 139.62,66.4 139.62,69.19 140.11,69.67 141.07,69.67
GND on TOP (solid shape): 151.99,63.22 151.99,61.82 151.69,61.52 148.26,61.52 148.08,61.34 145.19,61.34 144.92,61.61 144.92,62.05 146.55,63.68 151.54,63.68
GND on TOP (solid shape): 179.04,181.1 179.04,180.85 178.92,180.72 178.03,180.72 177.27,179.96 174.22,179.96 174.09,180.09 174.09,182.75 174.22,182.88 177.27,182.88
GND on TOP (solid shape): 183.41,230.2 183.41,227.53 183.29,227.41 182.32,227.41 182.12,227.61 182.12,230.33 182.35,230.56 183.06,230.56
GND on TOP (solid shape): 6.3,193.07 6.3,191.41 5.13,190.25 3.48,190.25 3.23,190.5 3.23,191.49 3.38,191.64 4.39,191.64 4.93,192.18 4.93,192.81 5.28,193.17 6.2,193.17
GND on TOP (solid shape): 28.09,115.11 28.09,111.94 28.5,111.53 30.73,111.53 31.06,111.2 31.06,108.41 29.01,106.35 26.14,106.35 25.3,107.19 25.3,115.06 25.78,115.54 27.66,115.54
GND on TOP (solid shape): 50.34,90.07 51.61,90.07 52.3,90.75 53.06,90.75 53.34,90.47 53.34,89.13 52.86,88.65 50.37,88.65 48.59,90.42 48.59,91.16 48.74,91.31 49.1,91.31
GND on TOP (solid shape): 74.78,72.59 74.78,71.48 74.68,71.37 70.43,71.37 70.31,71.5 70.31,72.39 70.69,72.77 74.6,72.77
GND on TOP (solid shape): 101.75,24.94 101.75,22.05 101.3,21.59 101.02,21.59 100.33,22.28 98.7,22.28 98.6,22.38 98.6,24.97 98.86,25.22 101.47,25.22
GND on TOP (solid shape): 110.1,223.99 111.14,223.99 111.35,223.77 111.35,219.91 111.1,219.66 106.48,219.66 105.59,220.55 105.59,221.28 108.31,224 110.08,224
GND on TOP (solid shape): 143.46,77.88 143.46,77.14 143.76,76.84 144.75,76.84 145.06,76.53 145.06,74.98 142.85,74.98 140.31,77.52 140.31,79.27 140.54,79.5 141.83,79.5
GND on TOP (solid shape): 48.13,116.03 48.13,112.4 47.88,112.14 46.38,112.14 46.37,112.15 46.37,113.19 46.36,113.28 46.33,113.37 46.33,115.93 46.89,116.48 47.68,116.48
GND on TOP (solid shape): 98.91,60.2 98.91,57.91 98.65,57.66 93.62,57.66 93.19,58.09 93.19,60.15 93.45,60.4 98.7,60.4
GND on TOP (solid shape): 103.86,5.18 103.86,3.18 103.48,2.79 98.17,2.79 97.94,3.02 97.94,4.83 98.68,5.56 103.48,5.56
GND on TOP (solid shape): 119.3,152.83 119.3,142.37 118.92,141.99 116.76,141.99 116.33,142.42 116.33,145.95 115.95,146.33 115.95,151.97 116.13,152.15 117.55,152.15 118.54,153.14 119,153.14
GND on TOP (solid shape): 132.94,196.47 132.94,193.42 132.82,193.29 131.62,193.29 131.56,193.23 131.03,193.23 130.79,192.99 130.25,192.99 130.02,193.22 130.02,195.86 130.17,196.01 130.89,196.01 131.47,196.6 132.82,196.6
GND on TOP (solid shape): 63.42,122.78 64.59,122.78 65.18,122.2 65.18,118.62 60.78,114.22 59.82,114.22 59.59,114.45 59.59,115.39 59.84,115.65 60.63,115.65 62.69,117.7 62.69,121.77 62.48,121.97 62.48,123.47 62.53,123.52 62.69,123.52
GND on TOP (solid shape): 123.88,79.5 123.88,76.33 123.62,76.07 117.3,76.07 117.25,76.12 115.75,76.12 113.58,78.3 113.58,78.31 113.13,78.75 113.13,79.22 113.39,79.48 122.5,79.48 122.89,79.86 123.52,79.86
GND on TOP (solid shape): 61.44,123.42 61.44,123.34 61.16,123.06 61.16,122.43 60.99,122.25 60.76,122.25 60.55,122.45 60.55,122.91 60.56,122.93 60.57,122.95 60.6,122.98 60.6,123.44 60.63,123.47 60.65,123.48 60.67,123.48 61.38,123.48
GND on TOP (solid shape): 73.35,65.18 73.35,64.94 72.47,64.06 72.45,64.04 72.43,64.04 72.22,64.04 72.09,63.9 72.07,63.89 72.05,63.89 71.84,63.89 71.69,64.04 71.69,64.08 71.86,64.24 71.86,64.63 72.57,65.35 73.18,65.35
GND on TOP (solid shape): 115.16,189.36 115.16,185.29 115.04,185.17 113.55,185.17 113.23,185.23 112.91,185.17 112.37,185.17 112.24,185.29 112.24,189.87 112.5,190.12 114.4,190.12
GND on TOP (solid shape): 73.56,150.98 73.56,150.09 73.11,149.64 72.58,149.64 71.91,148.97 71.4,148.97 71.32,149.05 71.32,149.66 71.48,149.81 71.86,149.81 71.88,149.81 72.36,150.29 72.36,150.32 72.62,150.57 72.62,151.03 72.72,151.13 73.41,151.13
GND on TOP (solid shape): 11.15,152.4 11.15,149.48 10.77,149.1 8.84,149.1 8.36,148.62 7.44,148.62 6.96,149.1 5.69,149.1 5.44,149.35 5.44,150.62 5.56,150.75 7.34,150.75 7.59,151 8.48,151 9.12,150.37 9.75,150.37 10.01,150.62 10.01,152.4 10.26,152.65 10.9,152.65
GND on TOP (solid shape): 71.67,43.53 72.18,43.53 72.23,43.48 72.27,43.48 72.28,43.46 72.51,43.46 73.38,42.59 73.38,41.91 73.25,41.78 72.92,41.78 72.76,41.94 72.76,41.96 71.84,42.88 71.83,42.89 71.83,42.91 71.83,43.09 71.73,43.19 71.35,43.19 71.23,43.31 71.23,43.5 71.3,43.56 71.64,43.56
GND on TOP (solid shape): 149.25,50.93 149.32,50.9 149.35,50.83 149.69,50.43 150.17,50.65 150.18,50.67 150.21,50.67 153.26,50.67 153.52,50.93 155.42,50.93 156.18,50.16 156.18,47.37 156.06,47.24 148.82,47.24 148.56,47.5 148.56,50.67 148.82,50.93
GND on TOP (solid shape): 90.12,242.7 90.12,227.91 87.73,225.53 87.73,222.53 88.24,222.02 88.62,222.02 88.75,221.89 88.75,221.18 88.67,221.11 87.48,221.11 84.71,223.88 84.71,225.6 82.42,227.89 82.42,230.03 86.58,230.03 86.58,233.53 84.28,233.53 84.28,230.03 82.42,230.03 82.42,232.94 81.76,233.6 74.6,233.6 73.91,232.92 73.91,229.87 73.91,228.55 72.87,227.51 69.67,227.51 68.73,226.57 68.73,223.39 67.94,222.61 65.1,222.61 64.62,222.12 64.62,220.47 65,220.09 65.43,220.09 65.63,219.89 65.63,219.48 65.23,219.07 63.07,219.07 62.59,219.56 62.59,230.03 69.2,230.03 69.2,233.53 66.9,233.53 66.9,230.03 62.59,230.03 62.59,242.65 63.04,243.1 89.71,243.1
GND on TOP (solid shape): 38.85,36.14 39.49,36.77 40.12,36.14 40.12,35.2 44.57,35.2 44.57,32 40.12,32 40.12,31.06 39.49,30.42 38.85,31.06 38.85,32 35.58,32 35.58,35.2 38.85,35.2
GND on TOP (solid shape): 70.68,57.68 70.75,57.67 70.92,57.54 71.14,57.59 71.17,57.62 71.21,57.58 71.22,57.57 71.31,57.45 71.45,57.4 71.47,57.4 71.62,57.26 71.63,57.26 71.66,57.19 71.65,57.16 71.62,57.06 71.64,56.96 71.65,56.93 71.6,56.89 71.27,56.89 71.11,56.73 71.08,56.74 70.94,56.75 70.82,56.69 70.72,56.67 70.65,56.74 70.59,56.85 70.49,56.91 70.47,56.92 70.36,57.15 70.37,57.17 70.41,57.24 70.43,57.33 70.43,57.39 70.42,57.45 70.44,57.51 70.48,57.55 70.56,57.59 70.61,57.65
GND on TOP (solid shape): 111.85,156.95 111.88,156.94 112.04,156.81 112.23,156.77 112.3,156.74 112.33,156.68 112.67,156.38 113.01,156.68 113.05,156.74 113.11,156.77 113.28,156.81 113.43,156.94 113.45,156.95 113.69,156.95 113.82,156.82 113.82,156.69 113.6,156.48 113.6,156.19 113.59,156.16 113.56,156.14 113.32,156.02 113.25,155.77 113.25,155.76 113.24,155.73 113.06,155.55 112.61,155.55 112.45,155.71 112.45,156.02 112.37,156.09 112.37,156.11 111.99,156.49 111.63,156.49 111.51,156.62 111.51,156.82 111.51,156.84 111.52,156.86 111.56,156.89 111.58,156.93 111.6,156.94 111.63,156.95
GND on TOP (solid shape): 51.1,64.7 52.2,64.7 52.33,64.57 52.34,64.55 52.34,64.53 52.38,64.39 52.49,64.3 52.5,64.29 52.76,64.03 52.76,63.98 53.14,63.6 53.14,63.42 53.03,63.32 53,63.31 52.97,63.31 52.87,63.35 52.76,63.36 52.74,63.36 52.69,63.4 52.69,63.41 52.45,63.58 52.21,63.42 52.21,63.41 52.04,63.25 51.8,63.25 51.8,63.25 51.71,63.26 51.62,63.25 51.62,63.25 51.4,63.25 51.39,63.25 51.23,63.29 51.08,63.26 51.04,63.26 51.01,63.29 50.99,63.33 50.97,63.36 50.94,63.43 50.97,63.5 50.94,63.89 50.55,63.87 50.53,63.86 50.51,63.85 50.28,63.85 50.26,63.86 50.24,63.87 49.97,64.14 49.97,64.51 50.47,65.01 50.79,65.01
GND on TOP (solid shape): 50.98,45.08 51.05,45.05 51.18,44.97 51.36,44.97 51.38,44.95 51.43,44.91 51.43,44.9 51.53,44.77 51.68,44.7 51.71,44.67 51.71,44.63 51.65,44.57 51.56,44.58 51.29,44.6 51.15,44.38 51.2,44.23 51.34,44.13 51.37,44.11 51.37,44.07 51.36,43.97 51.39,43.86 51.39,43.85 51.39,43.44 51.14,43.19 51.05,43.2 51.03,43.24 51.03,43.3 51.02,43.36 50.94,43.47 50.77,43.54 50.71,43.54 50.68,43.54 50.49,43.74 48.92,43.74 48.74,43.92 48.74,44.3 48.76,44.34 48.79,44.35 50.09,44.35 50.64,44.9 50.71,44.9 50.82,45.02 50.88,45.04 50.91,45.06
GND on TOP (solid shape): outline of 137 points within 31.62,1.85 50.52,11
GND on TOP (solid shape): 64.27,44.9 64.27,44.88 64.46,44.64 64.75,44.76 64.75,44.77 65.01,44.91 65.07,44.89 65.12,44.87 65.19,44.86 65.42,44.63 65.53,44.63 65.53,44.55 65.51,44.54 65.38,44.35 65.45,44.14 65.44,44.1 65.42,44.07 65.32,44.01 65.26,43.91 65.25,43.87 65.25,43.78 65.16,43.69 64.78,43.69 64.73,43.74 64.73,44.02 64.58,44.17 64.59,44.2 64.31,44.55 64.17,44.13 64.18,44.11 64.18,44.08 64.19,44.08 64.2,44.04 64.18,44 64.13,43.96 64.1,43.9 64.08,43.87 63.99,43.87 64,43.94 63.94,44.16 63.72,44.25 63.65,44.27 63.61,44.34 63.57,44.46 63.47,44.55 63.46,44.61 63.48,44.66 63.5,44.69 63.53,44.74 63.6,44.79 63.63,44.79 63.65,44.79 63.91,44.78 64.12,44.94 64.14,44.96 64.2,44.96
GND on TOP (solid shape): outline of 258 points within 31.67,1.85 40.67,10.85
GND on TOP (solid shape): outline of 259 points within 31.67,74.24 40.67,83.24
GND on TOP (solid shape): outline of 259 points within 189.15,206.32 198.15,215.32
GND on TOP (solid shape): outline of 259 points within 189.15,74.24 198.15,83.24
GND on TOP (solid shape): outline of 259 points within 189.15,1.85 198.15,10.85
GND on TOP (solid shape): outline of 121 points within 51.4,45.39 54.65,50.72
GND on TOP (solid shape): outline of 9228 points within 49.89,43.72 72.24,64.26
GND on BOTTOM (solid shape): 61.44,55.75 61.44,54.03 61.32,53.9 59.74,53.9 59.28,54.36 59.28,55.75 59.41,55.88 61.32,55.88
GND on BOTTOM (solid shape): 135.79,141.02 135.79,139.65 135.64,139.5 134.34,139.5 134.19,139.65 134.19,141.07 134.39,141.27 135.53,141.27
GND on BOTTOM (solid shape): 195.53,194.97 195.53,190.75 195.15,190.37 187.05,190.37 186.92,190.5 186.92,195.07 187.05,195.2 195.3,195.2
GND on BOTTOM (solid shape): 131.04,153.67 131.04,143 130.78,142.75 130.28,142.75 129.77,143.26 129.39,143.26 129.13,143.51 129.13,152.78 130.15,153.8 130.91,153.8
GND on BOTTOM (solid shape): 59.72,52.63 59.72,51.74 59.87,51.59 59.87,50.9 59.72,50.75 58.75,50.75 58.38,51.12 58.38,52.73 58.59,52.93 59.41,52.93
GND on BOTTOM (solid shape): 120.5,151.26 120.5,149.54 120.68,149.36 120.68,146.53 120.34,146.2 118.4,146.2 118.39,146.19 116.17,146.19 115.95,146.41 115.95,151.31 116.26,151.61 120.14,151.61
GND on BOTTOM (solid shape): 38.85,36.14 39.49,36.77 40.12,36.14 40.12,35.2 44.57,35.2 44.57,32 40.12,32 40.12,31.06 39.49,30.42 38.85,31.06 38.85,32 35.68,32 35.68,35.2 38.85,35.2
GND on BOTTOM (solid shape): 114.29,157.09 114.33,157.07 114.43,156.97 114.43,156.31 114.1,155.98 113.28,155.98 113.13,155.83 113.13,153.39 112.47,152.73 111.53,152.73 111.45,152.81 111.45,153.51 111.86,153.92 111.86,156.14 111.91,156.32 111.89,156.51 111.89,156.53 111.9,156.56 112.01,156.67 112.52,156.67 112.72,156.86 112.78,156.89 112.85,156.87 113.19,156.78 113.46,157.01 113.53,157.06 113.61,157.05 113.94,156.95 114.26,157.07
GND on BOTTOM (solid shape): outline of 252 points within 62.54,190.49 67.39,201.84
GND on BOTTOM (solid shape): outline of 395 points within 21.49,1.68 42.37,10.82
GND on BOTTOM (solid shape): outline of 26229 points within 54.97,81.36 180.9,147.6
GND on PWR (solid shape): 195.94,195.04 195.94,190.53 195.78,190.37 187.2,190.37 186.92,190.66 186.92,195.04 187.08,195.2 195.78,195.2
GND on PWR (solid shape): 146.3,198.95 146.33,198.85 146.24,198.78 145.99,198.09 146.68,198.34 146.75,198.42 146.86,198.4 146.91,198.34 146.91,195.36 145.61,194.06 144.66,194.06 142.21,196.5 142.21,198.85 142.37,199.01 146.25,199.01
GND on PWR (solid shape): 101.57,200.56 101.67,200.58 102.23,200.58 102.59,200.22 102.59,199.19 101.68,198.28 101.68,192.28 101.67,192.26 101.66,192.25 101.43,192.02 101.32,192.02 101.28,192.04 101.27,192.07 101.28,192.11 101.05,192.81 100.66,192.18 100.67,192.08 100.58,192.02 98.81,192.02 98.65,192.18 98.65,198.85 100.39,200.58 101.52,200.58
GND on PWR (solid shape): outline of 108 points within 122.91,205.36 127.61,210.95
GND on PWR (solid shape): outline of 108 points within 172.57,179.07 185.9,182.88
GND on PWR (solid shape): outline of 165 points within 109.45,183.39 116.18,200.13
GND on PWR (solid shape): outline of 183 points within 186.66,174.37 192,181.86
GND on PWR (solid shape): 54.61,44.7 54.62,44.68 54.69,44.52 54.83,44.41 54.85,44.4 54.86,44.38 54.86,43.89 55.27,43.48 55.27,41.07 54.39,40.19 54.3,40.17 54.23,40.23 54.2,40.28 54.16,40.33 54.14,40.4 54.16,40.47 53.87,41.1 53.59,40.47 53.61,40.4 53.59,40.33 53.49,40.1 53.56,39.86 53.57,39.82 53.56,39.79 53.19,39.42 53.19,39.17 53.17,39.13 53.14,39.12 52.57,39.12 52.42,38.96 52.05,38.96 51.96,39.02 51.96,39.12 52.02,39.34 51.94,39.55 51.93,39.63 51.98,39.7 52.06,39.76 52.12,39.83 52.18,39.88 52.25,39.87 52.62,39.88 52.81,40.19 52.84,40.25 52.9,40.28 53.15,40.94 52.5,40.69 52.47,40.62 52.41,40.59 52.23,40.54 52.1,40.41 52.04,40.36 51.97,40.37 51.5,40.28 51.48,39.8 51.5,39.72 51.45,39.65 51.44,39.64 51.33,39.64 51.28,39.73 51.28,40.46 52.86,42.04 52.96,42.04 53.54,42.62 53.54,43.03 53.8,43.28 53.8,43.68 53.8,43.7 53.81,43.72 53.91,43.93 53.84,44.19 53.85,44.23 54.38,44.75 54.56,44.75
GND on PWR (solid shape): outline of 291 points within 90.53,192.28 99.97,204.22
GND on PWR (solid shape): outline of 352 points within 3.53,66.68 22.83,79.38
GND on PWR (solid shape): outline of 335 points within 35.66,30.35 49.5,36.7
GND on PWR (solid shape): outline of 402 points within 54.84,112.14 74.02,132.59
GND on PWR (solid shape): outline of 406 points within 23.34,101.35 51.66,117.98
GND on PWR (solid shape): outline of 591 points within 86.33,64.52 110.08,73.79
GND on PWR (solid shape): outline of 591 points within 33.88,178.44 45.95,185.04
GND on PWR (solid shape): outline of 668 points within 44.17,123.57 74.02,140.59
GND on PWR (solid shape): outline of 1051 points within 3.53,14.22 31.43,29.46
GND on PWR (solid shape): outline of 1269 points within 86.72,212.72 111.35,243.33
GND on PWR (solid shape): outline of 1410 points within 131.8,215.14 163.8,243.33
GND on PWR (solid shape): outline of 1458 points within 111.86,213.36 136.88,243.33
GND on PWR (solid shape): outline of 1464 points within 3.53,29.72 29.82,69.6
GND on PWR (solid shape): outline of 2930 points within 156.82,217.55 199.49,243.33
GND on PWR (solid shape): outline of 3285 points within 36.42,55.35 83.92,91.31
GND on PWR (solid shape): outline of 4124 points within 153.14,192.53 199.49,225.93
GND on PWR (solid shape): outline of 4301 points within 44.04,182.88 90.12,243.33
GND on PWR (solid shape): outline of 7449 points within 13.44,114.43 67.67,185.04
GND on PWR (solid shape): outline of 7661 points within 54.97,81.28 113.64,144.4
