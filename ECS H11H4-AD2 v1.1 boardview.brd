# Allegro board ECS H11H4-AD2 v1.1 boardview.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
SLP_S0_L: length 7
  TOP w0.089: PCH1.BC26 63.23,43.7 62.89,43.35 62.89,43.23 62.86,43.2 62.86,42.77 62.75,42.66 62.75,38.44 v3(62.97,38.23)
  BOTTOM w0.089: v3(62.97,38.23) 62.97,38.4 62.33,39.04 STP72.1
SLP_S3_L: length 756.1
  TOP w0.089: PCH1.AW15 v3(57.07,45.95)
  TOP w0.102: v1(154.74,63.6) 155.4,62.94 155.4,60.25 153.7,58.55 153.7,57.63 155.14,56.18 155.14,53.17 153.41,51.44 v1(148.01,51.44) ; U30.5 16.82,77.46 13.87,80.42 v1(12.6,80.42) 6.43,80.42 4.06,82.78 v1(3.51,82.78) ; v1(41.2,12.52) 41.12,12.52 40.74,12.9 40.74,19.35 41.12,19.74 41.12,23.67 41.68,24.23 v1(41.68,24.92) ; R401.1 155.65,73.28 v1(156.87,72.06) ; U40.5 21.27,26.98 v1(22.45,28.17) ; v1(104.5,39.67) 104.11,40.06 102.79,40.06 102.18,40.67 102.18,41.15 101.8,41.53 101.8,45.82 v1(102.06,46.08) ; U20.5 77.74,200.01 76.99,199.26 73.79,199.26 v1(73.66,199.14) 74.63,198.17 77.15,198.17 87.18,208.2 94.58,208.2 99.54,213.17 99.54,216.66 100.97,218.09 100.97,218.49 101.39,218.9 102.53,218.9 103.61,217.83 103.61,216.36 102.96,215.72 U15.1 ; v1(54.05,178.84) 54.05,178.49 51.64,176.07 41.22,176.07 40.56,175.41 36.78,175.41 34.82,177.37 31.39,177.37 29.03,179.73 v1(28.85,179.73) ; v1(2.06,131.72) 5.64,131.72 6.93,130.43 8.71,130.43 R305.1 ; R517.1 133.4,50.51 132.66,49.78 v1(132.66,49.78) ; v1(14.94,54.38) 12.8,54.38 11.89,55.3 11.89,60.73 12.88,61.73 U33.1 ; v1(112.27,36.47) 114.66,34.09 114.66,31.17 114.19,30.7 U38.30 114.19,28.94 114.53,28.6 115.67,28.6 116.56,27.71 116.56,24.82 118.87,22.5 118.87,3.23 117.45,1.8 80.19,1.8 v1(78.13,3.86)
  BOTTOM w0.089: 54.25,36.32 54.25,36.8 55.09,37.64 56.08,37.64 56.77,38.33 56.77,42.32 57.41,42.96 57.41,44.82 57.28,44.96 57.28,45.74 v3(57.07,45.95)
  BOTTOM w0.102: v1(102.06,46.08) 102.44,45.69 112.22,45.69 112.57,45.34 119.91,45.34 122.05,47.47 130.99,47.47 132.66,49.15 v1(132.66,49.78) 133.41,50.53 134.1,50.53 136.07,52.5 140.72,52.5 142.11,51.1 147.68,51.1 v1(148.01,51.44) ; v1(73.66,199.14) 73.66,196.27 65.28,187.88 63.92,187.88 54.88,178.84 v1(54.05,178.84) ; 54.25,36.32 54.25,34.82 54.18,34.75 54.18,30.71 52.86,29.39 52.65,29.39 51.85,28.59 50.94,28.59 50.52,28.17 49.86,28.17 47.09,25.4 47.08,25.4 46.93,25.25 45.77,25.25 45.19,24.66 43.21,24.66 42.93,24.38 41.91,24.38 41.68,24.61 v1(41.68,24.92) ; v1(156.87,72.06) 157.2,71.73 157.2,68.76 154.38,65.94 154.38,63.96 v1(154.74,63.6) ; v1(104.5,39.67) 104.93,39.67 108.33,36.27 112.06,36.27 v1(112.27,36.47) ; v1(22.45,28.17) 22.45,28.22 21.97,28.7 21.97,29.09 21.23,29.83 21.23,30.94 20.24,31.93 20.24,46.6 15.77,51.07 15.77,53.54 v1(14.94,54.38) 14.94,54.62 15.77,55.46 15.77,67.26 14.99,68.05 14.99,77.28 12.6,79.67 v1(12.6,80.42) 11.18,81.84 11.18,101.93 23.22,113.97 23.22,123.8 27.53,128.12 27.53,139.65 26.8,140.39 26.8,177.67 v1(28.85,179.73) ; 7.85,142.49 7.09,142.49 5.89,141.3 5,141.3 2.06,138.35 v1(2.06,131.72) 1.73,131.39 1.73,86.87 3.25,85.34 3.25,83.03 v1(3.51,82.78) 1.65,80.92 1.65,19.76 3.1,18.31 3.1,16.87 9.83,10.13 30.33,10.13 33.17,12.98 39.09,12.98 39.55,12.52 v1(41.2,12.52) 41.78,12.52 42.32,11.99 44.21,11.99 46.18,10.02 46.18,5.87 47.8,4.24 53.04,4.24 53.67,3.61 77.88,3.61 v1(78.13,3.86)
SLP_S3_L_R: length 4.3
  TOP w0.254: QN23.3 134.55,45.99 v1(134.79,46.23) QN24.2
SLP_S4_L: length 551.6
  TOP w0.089: PCH1.BD15 57.41,43.18 57.46,43.13 57.46,42.62 57.75,42.33 57.75,42.08 57.89,41.94 57.89,40.26 57.51,39.88 57.51,39.24
  TOP w0.102: 57.51,39.24 57.51,34.01 56.41,32.92 56.41,30.71 56.9,30.23 56.9,28.58 53.7,25.37 51.16,25.37 49,27.53 47.85,27.53 46.72,28.66 42.28,28.66 41.27,27.66 41.27,25.78 40.44,24.94 40.44,20.04 40.06,19.66 40.06,17.78 36.42,14.15 35.43,14.15 34.87,14.71 v1(34.87,15.06) ; v1(34.9,125.22) 35,125.32 40.51,125.32 50.52,135.33 57.23,135.33 57.73,135.84 61.42,135.84 69.57,143.99 R297.1 ; v1(125.65,34.9) 125.81,34.9 126.54,34.16 126.54,33.45 124.21,31.12 124.21,27.48 v1(123.98,27.25) 123.7,27.53 119.1,27.53 118.57,28.07 117.91,28.07 117.41,28.56 117.41,31.38 116.96,31.84 U38.35 ; v1(80.04,13.54) 79.76,13.82 79.07,13.82 78.66,13.41 77.75,13.41 77.06,14.1 75.26,14.1 74.96,13.79 74.96,12.88 74.32,12.24 74.32,7.98 75.59,6.71 v1(75.59,4.65) ; U43.2 78.46,15.37 v1(78.13,15.7) ; v1(3.99,84.81) 4.51,84.81 R385.2 5.63,83.69 6.93,83.69 7.52,84.28 11.91,84.28 13.72,82.47 v1(17.88,82.47) ; v1(30.18,22.86) 29.67,22.35 29.67,22.07 28.14,20.54 27.47,20.54 24.79,17.85 24.79,17.18 21.87,14.26 21.87,12.39 21.88,12.38 21.88,11.9 v1(22.15,11.63) ; R400.1 156.24,74.42 v1(156.64,74.02) ; v1(149.78,50.85) 153.19,50.85 155.4,53.06 155.4,56.29 153.95,57.73 153.95,58.45 155.65,60.15 155.65,63.47 v1(155.5,63.63)
  BOTTOM w0.102: v1(155.5,63.63) 154.66,64.47 154.66,65.89 157.43,68.66 157.43,72.29 156.67,73.05 156.67,73.99 v1(156.64,74.02) ; v1(30.18,22.86) 30.1,22.78 26.85,22.78 25.53,24.1 25.53,28.73 25.78,28.98 25.78,34.29 24.16,35.92 24.16,47.69 19.56,52.29 19.56,68.73 18.64,69.65 18.64,81.71 v1(17.88,82.47) 17.88,83.54 14.96,86.46 14.96,99.59 18.36,103 19.71,103 22.35,105.64 22.35,107.14 33.05,117.83 33.05,118.65 34.7,120.3 34.7,123.27 34.34,123.62 34.34,124.66 v1(34.9,125.22) ; v1(125.65,34.9) 125.81,34.9 126.21,34.49 126.75,34.49 129.67,37.41 130.96,37.41 131.93,38.38 131.93,41.2 135.64,44.91 135.64,47.24 135.18,47.7 135.18,48.67 135.92,49.4 141.12,49.4 141.88,50.16 149.1,50.16 v1(149.78,50.85) ; v1(22.15,11.63) 22.22,11.58 22.76,11.05 27.66,11.05 28.91,12.29 31.11,12.29 33.43,14.6 34.42,14.6 v1(34.87,15.06) 34.87,14.78 35.51,14.15 36.42,14.15 36.93,14.66 38.4,14.66 39.6,13.46 41.86,13.46 42.65,12.67 44.5,12.67 46.86,10.31 46.86,6.17 48.08,4.95 53.42,4.95 54.03,4.34 75.29,4.34 v1(75.59,4.65) 75.77,4.83 79.07,4.83 80.16,3.73 100.58,3.73 103.33,6.48 106.02,6.48 107.98,4.52 114.45,4.52 116.36,6.43 121.23,6.43 121.77,5.89 122.43,5.89 123.95,7.42 123.95,11.48 123.47,11.96 123.47,26.75 v1(123.98,27.25) ; v1(78.13,15.7) 80.04,13.79 v1(80.04,13.54) ; v1(3.99,84.81) 3.99,85.32 2.21,87.1 2.21,130.3 2.92,131.01 2.92,136.88 4.8,138.76 5.51,138.76 6.71,139.95 7.85,139.95
SLP_S4_L_R: length 4.5
  TOP w0.102: QN19.1 8.13,83.29 R385.1 4.31,83.29 v2(4.01,83.59)
SLP_S4_L_R_D: length 91.9
  TOP w0.102: v1(5.18,10.31) 5.18,10.06 2.87,7.75 2.87,5.4 Q40.E ; R384.2 6.34,86.79 QN19.3
  TOP w0.152: v1(2.36,84.48) 3.3,85.42 4.78,85.42 5.74,84.46 QN19.3 ; v1(2.03,82.09) 1.5,81.56 1.5,15.27 2.08,14.68 v1(4.01,14.68)
  BOTTOM w0.102: v1(5.18,10.31) v2(5.18,13.18) 5.18,13.51 v1(4.01,14.68)
  BOTTOM w0.152: v1(2.03,82.09) 2.03,84.15 v1(2.36,84.48)
SLP_WLAN_L: length 20.7
  TOP w0.089: PCH1.AV13 56.46,46.49 v3(56.05,46.08)
  TOP w0.102: R682.1 50.91,28.55 50.91,29.17 51.59,29.84 v1(51.59,30.33)
  BOTTOM w0.089: v3(56.05,46.08) 56.44,45.7 56.44,45.19 55.91,44.65 55.91,43.36 55.5,42.95 55.5,38.66 53.16,36.32
  BOTTOM w0.102: 53.16,36.32 53.04,36.19 53.04,34.7 52.7,34.37 52.7,31.34 STP74.1 52.17,30.91 v1(51.59,30.33)
SLPSUS_L: length 149.9
  TOP w0.089: PCH1.BB13 56.54,44.09 56.67,43.96 56.67,43.28 56.74,43.21 56.74,41.73 57.07,41.4 57.07,36.98 57.05,36.96
  TOP w0.102: v1(83.31,45.31) 83.31,44.81 84.51,43.61 85.37,43.61 85.55,43.79 86.28,43.79 86.82,43.26 89.76,43.26 91.31,44.81 91.31,47.52 92.79,49 95.78,49 96.34,49.56 97.21,49.56 v1(97.46,49.81) ; U38.64 108.9,38.83 108.71,39.01 106.12,39.01 104.8,40.34 102.84,40.34 102.41,40.77 102.41,41.25 102.03,41.63 102.03,44.45 v1(102.44,44.86) ; R522.2 140.44,51 v1(140.06,51.38) ; v1(56.06,28.75) 56.44,29.13 56.44,30.02 55.96,30.51 55.96,33.12 57.05,34.21 57.05,36.96
  TOP w0.254: R522.2 140.63,50.51 R523.1
  BOTTOM w0.102: v1(140.06,51.38) 138.58,49.91 135.13,49.91 130.99,45.77 121.82,45.77 120.52,44.48 102.82,44.48 v1(102.44,44.86) 102.41,44.86 v1(97.46,49.81) ; v1(56.06,28.75) v2(56.06,27.56) 55.73,27.23 55.73,25.1 56.82,24 60.63,24 60.96,24.33 65.2,24.33 65.84,24.97 69.42,24.97 70,25.55 78.59,25.55 82.22,29.18 82.22,39.29 80.77,40.74 80.77,41.76 81.28,42.27 81.91,42.27 83.31,43.66 v1(83.31,45.31)
SLS3_BF: length 24.3
  TOP w0.102: R340.1 9.7,120.08 9.7,122.37 R328.1 R319.1 9.5,124.9 9.5,129.05 R309.1 9.6,130.17 9.6,135.46 9.04,136.02 7.13,136.02 v1(6.29,135.18) 6.29,134.83 QN16.3 4.2,134.11 R302.1
SMBALERT_L: length 22.6
  TOP w0.089: PCH1.BB41 71.1,44.12 v3(71.25,43.97) ; 79.22,39.85 76.02,43.05 v3(76.02,43.36)
  TOP w0.102: 79.22,39.85 79.76,39.32 81.36,39.32 83.36,37.31 87.6,37.31 88.21,37.92 R596.1 R590.1
  BOTTOM w0.089: v3(76.02,43.36) 75.29,42.63 72.41,42.63 v2(71.98,43.05) 71.98,43.23 v3(71.25,43.97)
SMBCLK_MAIN: length 201
  TOP w0.102: v1(84.25,32.36) 88.09,32.36 90.86,35.13 94.08,35.13 v1(94.54,35.59) ; R717.1 72.52,25.27 72.52,24.05 71.93,23.47 71.93,21.69 v1(71.68,21.44) ; v1(102.39,78.18) 101.88,78.69 101.4,78.69 100.71,79.38 60.88,79.38 60.2,78.69 56.49,78.69 54.31,80.87 54.31,84.4 48.29,90.42 48.29,92.3 50.47,94.49 50.47,98.25 51.54,99.31 R364.1 ; v1(42.72,22.45) 42.21,22.45 R728.1 42.01,20.88 QN33.2
  BOTTOM w0.102: v1(42.72,22.45) 43.33,22.45 43.66,22.78 48.11,22.78 49.23,23.9 49.23,25.55 49.72,26.05 50.46,26.05 51.38,26.97 52.37,26.97 52.78,26.57 52.78,23.19 54.28,21.69 60.66,21.69 61.72,20.62 69.21,20.62 70.33,19.51 71.37,19.51 72.26,20.4 72.26,20.83 71.68,21.41 ; v1(102.39,78.18) 103.71,76.86 103.71,65.61 99.19,61.09 96.7,61.09 95.86,60.25 95.86,54.43 94.08,52.65 94.08,48.49 95.35,47.22 95.35,45.09 94.84,44.58 94.84,35.89 v1(94.54,35.59) ; v1(84.25,32.36) 84.45,32.16 v2(84.45,30.12) 84.81,29.77 84.81,28.75 79.88,23.83 79.88,22.83 79.07,22.02 75.34,22.02 74.85,21.54 71.81,21.54 71.68,21.41 ; 71.68,21.41 v1(71.68,21.44)
SMBCLK_STBY: length 332.5
  TOP w0.102: v1(25.3,128.63) 25.83,128.63 29.54,132.33 v1(29.54,132.61) ; v1(43.36,14.35) 43.36,14 43.08,13.72 42.77,13.72 42.52,13.97 42.52,15.8 42.77,16.05 44.2,16.05 44.73,16.59 44.73,19.05 44.4,19.38 43.85,19.38 QN33.3 43.15,19.35 43.69,19.89 44.45,19.89 44.73,20.17 44.73,21.33 45.43,22.03 R726.1 45.43,23.55 v1(45.03,23.95) ; PCIE16X.B5 16.18,193.96 16.48,193.65 19.25,193.65 20.19,194.59 25.17,194.59 v1(25.76,195.17) 26.34,194.59 36.3,194.59 PCIE1X.B5 ; R570.1 80.94,41.71 v1(81.46,41.71) 82.02,41.71 C560.1
  BOTTOM w0.102: v1(45.03,23.95) 45.49,23.5 46.43,23.5 46.96,24.03 46.96,24.28 50.16,27.48 50.88,27.48 51.08,27.69 54.51,27.69 54.89,27.31 54.89,24.74 56.51,23.11 61.9,23.11 62.43,23.65 65.38,23.65 66.04,24.31 69.47,24.31 70.13,24.97 78.65,24.97 82.68,28.99 82.68,40.49 v1(81.46,41.71) ; v1(43.36,14.35) 42.82,14.88 40.21,14.88 39.01,16.08 33.54,16.08 30.67,13.21 24.79,13.21 23.55,14.45 18.98,14.45 15.32,18.12 15.32,19.2 11.61,22.91 11.61,26.77 10.77,27.61 10.77,51.79 8.66,53.9 8.66,59.16 6.88,60.93 6.88,64.8 8.97,66.88 8.97,102.06 21.62,114.71 21.62,126.16 24.08,128.63 v1(25.3,128.63) 25.7,129.03 25.7,139.09 25.12,139.67 25.12,194.54 v1(25.76,195.17) ; SR15.1 29.92,128.21 29.92,132.23 v1(29.54,132.61)
SMBCLK_STBY_R: length 10.8
  TOP w0.089: PCH1.AW44 72.1,45.56 73.58,45.56 74.34,44.81 74.5,44.81 74.9,45.21 75.77,45.21 78.35,42.63 78.35,42.15 79.15,41.35 79.22,41.35
  TOP w0.102: 79.22,41.35 79.53,41.35 79.74,41.56 R570.2
SMBDATA_MAIN: length 219.4
  TOP w0.102: v1(80.21,19.61) 81.56,18.26 88.52,18.26 89.64,19.38 89.64,20.73 87.86,22.5 87.86,24.71 88.24,25.1 88.24,25.88 R707.1 ; v1(101.63,78.1) 100.58,79.15 60.99,79.15 60.3,78.46 56.39,78.46 54.08,80.77 54.08,84.3 48.06,90.32 48.06,92.47 50.19,94.6 50.19,96.93 48.62,98.5 48.62,99.35 R363.1 ; v1(84.96,31.85) 87.91,31.85 90.93,34.87 94.31,34.87 v1(94.56,34.62) ; R727.1 44.06,22.31 v1(44.12,22.25) 44.12,21.92 43.46,21.26 43.46,20.5 42.32,19.35 42.32,17.89 42.2,17.78 QN35.2
  BOTTOM w0.102: v1(44.12,22.25) 44.42,22.56 48.21,22.56 49.45,23.8 49.45,25.45 49.81,25.81 50.55,25.81 51.49,26.75 52.27,26.75 52.55,26.47 52.55,22.61 v2(53.21,21.95) 53.7,21.46 60.55,21.46 61.72,20.29 69.21,20.29 70.26,19.25 71.48,19.25 72.54,20.32 72.54,20.83 73.02,21.31 74.96,21.31 75.44,21.79 79.22,21.79 ; v1(94.56,34.62) 94.03,35.15 94.03,36.14 94.61,36.73 94.61,44.73 95.12,45.24 95.12,47.09 93.83,48.39 93.83,52.76 95.58,54.51 95.58,60.38 96.57,61.37 99.06,61.37 103.43,65.74 103.43,76.3 v1(101.63,78.1) ; v1(80.21,19.61) 80.21,20.8 79.22,21.79 ; 79.22,21.79 80.16,22.73 80.16,23.77 85.06,28.68 85.06,31.75 v1(84.96,31.85)
SMBDATA_STBY: length 326.3
  TOP w0.102: v1(44.09,14.35) 44.09,14.55 43.79,14.86 43.55,14.86 QN35.3 43.15,15.49 43.28,15.62 44.17,15.62 44.96,16.41 44.96,21.23 46.18,22.46 R729.1 46.05,22.92 46.05,23.72 v1(45.8,23.98) ; PCIE1X.B6 33.63,194.26 25.86,194.26 v1(25.76,194.36) 25.65,194.26 20.22,194.26 19.35,193.4 PCIE16X.B6 ; v1(30.2,132.99) 30.2,132.59 25.68,128.07 24.99,128.07 v1(24.92,127.99) ; C568.1 81.64,40.89 v1(81.51,40.77) 81.38,40.89 R584.1
  BOTTOM w0.102: SR16.1 30.2,128.11 v1(30.2,132.99) ; v1(44.09,14.35) 43.33,15.11 40.31,15.11 39.12,16.31 33.45,16.31 30.58,13.44 24.89,13.44 23.64,14.68 19.08,14.68 15.6,18.16 15.6,19.25 11.86,22.99 11.86,26.87 11,27.74 11,51.94 8.89,54.05 8.89,59.41 7.24,61.06 7.24,64.83 9.19,66.78 9.19,101.93 21.84,114.58 21.84,126.06 23.77,127.99 v1(24.92,127.99) 25.37,127.99 26.09,128.7 26.09,139.04 25.37,139.75 25.37,193.98 v1(25.76,194.36) ; v1(81.51,40.77) 82.45,39.83 82.45,29.09 78.56,25.2 70.03,25.2 69.37,24.54 65.91,24.54 65.28,23.9 62.36,23.9 61.8,23.34 56.62,23.34 55.12,24.84 55.12,27.46 54.64,27.94 51,27.94 50.77,27.71 50.06,27.71 47.14,24.79 46.23,24.79 45.8,24.36 v1(45.8,23.98)
SMBDATA_STBY_R: length 11.1
  TOP w0.089: v3(74.35,44.09) 74.35,44.37 74.96,44.98 75.72,44.98 78.16,42.55 78.16,42.06 79.22,41 ; v3(71.93,44.52) 71.84,44.43 PCH1.BB43
  TOP w0.102: R584.2 79.32,40.89 79.22,41
  BOTTOM w0.089: v3(74.35,44.09) 73.36,44.09 v2(73,44.45) 72.93,44.52 v3(71.93,44.52)
SMCLK_DIMM: length 19.6
  TOP w0.102: R364.2 C395.1 53.17,100.45 53.17,99.73 53.63,99.26 55.93,99.26 56.26,98.93 57.09,98.93 DIMM2.118 57.84,95.58 57.02,94.77 57.02,93.9 57.84,93.09 57.84,92.07 58.85,91.06 58.85,89.01 DIMM1.118
SMDATA_DIMM: length 27.5
  TOP w0.102: DIMM1.238 58.07,84.43 58.07,87.2 58.56,87.69 58.56,88.38 59.11,88.93 59.11,91.24 58.12,92.23 58.12,94.11 DIMM2.238 58.09,94.63 58.09,97.1 58.55,97.56 58.55,98.48 57.86,99.16 56.38,99.16 56.05,99.49 53.75,99.49 53.42,99.82 53.42,101.35 53.01,101.75 51.21,101.75 C394.1 R363.2
SML0_CLK: length 12.8
  TOP w0.089: v3(71.21,44.94) PCH1.AY44 ; 79.22,39.45 v3(75.03,43.64)
  TOP w0.102: R591.1 79.88,38.79 79.22,39.45
  BOTTOM w0.089: v3(71.21,44.94) 71.21,44.67 72.73,43.15 v2(74.27,43.15) 74.55,43.15 v3(75.03,43.64)
SML0_DATA: length 17.8
  TOP w0.089: v3(69.4,43.94) PCH1.BB39
  TOP w0.102: v1(79.73,35.1) 80.37,34.47 R634.1
  BOTTOM w0.089: v3(69.4,43.94) 69.8,44.34 70.38,44.34 70.61,44.11 70.61,43.28 72.59,41.3 v2(74.7,41.3) 75.9,41.3 79.48,37.72
  BOTTOM w0.102: 79.48,37.72 79.73,37.47 v1(79.73,35.1)
SML0ALERT_L: length 21.3
  TOP w0.089: v3(69.79,45.37) PCH1.BA40
  TOP w0.102: v3(82.17,43.79) 82.52,43.79 83.72,42.6 83.72,41.15 84.53,40.34 84.54,40.34 R585.1 84.49,39.83 R588.1
  BOTTOM w0.089: v3(69.79,45.37) 69.79,45.74 v2(70.18,46.13) 70.47,46.42 71.82,46.42 72.65,45.59 75.03,45.59 76.5,44.12 79.48,44.12
  BOTTOM w0.102: 79.48,44.12 81.84,44.12 v3(82.17,43.79)
SML1_CLK: length 73.6
  TOP w0.089: v3(75.08,44.35) 75.72,44.35 76.53,43.54 76.53,42.98 79.22,40.28 ; v3(71.34,45.79) PCH1.AW42
  TOP w0.102: C574.1 84.31,39.01 82.04,39.01 81.51,39.55 79.96,39.55 79.22,40.28 ; C574.1 84.84,39.55 89.05,39.55 90.37,40.87 90.37,42.75 92.05,44.42 92.05,47.45 93.09,48.49 96.47,48.49 v1(96.82,48.84) ; C574.1 R595.2 ; U38.11 106.65,33.04 106.12,32.51 106.12,32.26 105.59,31.72 103.43,31.72 103.2,31.5 103.2,31.04 103.4,30.84 103.4,30.45 103.07,30.12 102.69,30.12 102.34,30.48 100.71,30.48 100.33,30.86 99.95,30.86 99.64,30.56 99.64,30.07 98.91,29.34 v1(97.99,29.34)
  BOTTOM w0.089: v3(75.08,44.35) 74.32,45.11 72.59,45.11 71.91,45.79 v3(71.34,45.79)
  BOTTOM w0.102: v1(97.99,29.34) 97.99,31.65 96.11,33.53 96.11,35.23 v2(96.39,35.51) 96.06,35.84 96.06,38.1 98.58,40.61 98.58,43.99 98.02,44.55 97,44.55 96.55,45.01 96.55,48.56 v1(96.82,48.84)
SML1_DATA: length 63.3
  TOP w0.089: PCH1.AW45 75.81,45.83 79.04,42.6
  TOP w0.102: v1(102.46,39.37) 101.6,39.37 100.13,40.84 100.13,41.81 100.63,42.32 100.63,47.02 98.32,49.33 96.47,49.33 95.88,48.74 92.94,48.74 91.59,47.4 91.59,44.4 90.14,42.95 90.14,42.02 89.3,41.17 R580.2 C571.1 87.73,40.64 84.61,40.64 83.95,41.3 83.95,42.72 82.45,44.22 81.94,44.22 81.69,43.97 81.69,43.56 81.84,43.41 81.84,42.9 81.53,42.6 79.04,42.6 ; U38.57 111.79,37.01 v1(111.64,36.86)
  BOTTOM w0.102: v1(111.64,36.86) 111.28,36.5 109.07,36.5 v2(108.08,37.49) 105.38,40.18 103.28,40.18 v1(102.46,39.37)
SML1ALERT_L: length 31
  TOP w0.089: v3(63.8,47.43) PCH1.AT27
  TOP w0.102: R679.1 v1(74.85,28.8) R678.1
  BOTTOM w0.089: 65.89,40.58 65.23,41.25 65.23,42.56 64.16,43.62 64.16,44.88 64.24,44.96 64.24,46.99 v3(63.8,47.43)
  BOTTOM w0.102: 65.89,40.58 67.6,40.58 70.99,37.19 70.99,34.11 70.13,33.25 69.49,33.25 68.76,32.51 68.76,30.53 70.15,29.13 73.67,29.13 v2(74.01,28.8) v1(74.85,28.8)
SPI0_IO2: length 11.6
  TOP w0.089: PCH1.BC29 64.33,43.75 63.99,43.42 63.99,43.18 64.01,43.16 64.01,43.15 64.07,43.09 64.07,42.53 64.1,42.5 64.1,42.49 64.15,42.43 64.15,41.93 63.88,41.66 v3(63.88,41.12)
  BOTTOM w0.089: v3(63.88,41.12) 64.26,41.12 66.83,38.56 v2(67.36,38.56) 68.05,38.56 68.4,38.21 SR27.1 SR29.1 68.4,36.32
  BOTTOM w0.102: SR31.1 68.4,36.32
SPI0_IO3: length 8.8
  TOP w0.089: 65.03,36.96 R597.1 65.03,38.71 64.9,38.84 64.9,41.17 64.74,41.33 64.74,42.67 64.67,42.75 64.67,43.24 64.84,43.42 PCH1.BD30
  TOP w0.102: R619.2 65.03,36.26 R610.1 65.03,36.96
SPI_CLK: length 9.1
  TOP w0.089: R602.1 68.22,38.86 66.6,38.86 66.17,39.29 66.17,40.54 65.16,41.54 65.16,41.6 65.16,43.35 65.51,43.69 PCH1.BC31
SPI_CLK0: length 36.2
  TOP w0.102: R602.2 69.62,36.51 v1(69.62,35.81) ; v1(66.93,31.88) 66.62,31.57 66.62,20.14 65.45,18.97 65.45,17.36 SPI_DEBUG.8 65.46,16.16 65.17,15.87 65,15.87 64.57,15.44 63.76,15.44 63.57,15.25 63.57,11.55 62.97,10.95 62.97,10.36 63.83,9.5 63.83,8.79 63.55,8.51 SPIROM1.6
  BOTTOM w0.102: v1(66.93,31.88) 67.44,31.88 v2(67.79,32.23) 69.14,33.58 69.14,33.81 69.62,34.29 v1(69.62,35.81)
SPI_CS_L0: length 52.5
  TOP w0.089: PCH1.BD31 65.51,43.26 65.35,43.1 65.35,41.68 66.67,40.36 v3(66.67,39.42)
  TOP w0.102: v1(70.89,9.19) 70.89,7.42 R763.1 ; v1(66.71,34.85) 65.96,34.11 65.96,29.69 66.27,29.39 66.27,20.53 64.85,19.11 64.85,16.03 64.49,15.67 63.5,15.67 62.92,15.09 SPI_DEBUG.3 62.92,11.86 62.18,11.13 v1(62.18,10.52)
  BOTTOM w0.089: 68.88,36.32 68.88,38.02 67.49,39.42 v3(66.67,39.42)
  BOTTOM w0.102: v1(62.18,10.52) 62.76,9.93 68.83,9.93 v2(69.04,9.73) 70.35,9.73 v1(70.89,9.19) ; v1(66.71,34.85) 66.71,34.84 67.79,33.76 68.45,33.76 68.88,34.19 68.88,36.32
SPI_IO2_0: length 38.4
  TOP w0.102: v1(68.12,34.34) 67.69,34.34 67.41,34.06 67.41,32.94 67.89,32.46 67.89,29.34 67.21,28.65 67.21,19.9 67.06,19.75 67.06,19.66 66.19,18.8 66.19,15.85 65.46,15.11 SPI_DEBUG.7 65.46,12.3 65.05,11.89 65.05,11.13 65.51,10.67 67.84,10.67 69.65,12.47 R748.2 C635.1 69.9,11.33 69.07,10.49 69.07,8.86 68.71,8.51 SPIROM1.3
  BOTTOM w0.102: v1(68.12,34.34) 67.44,35.02 SR31.2
SPI_IO3_0: length 42.2
  TOP w0.102: R619.1 65.38,34.96 65.38,29.99 v2(65.03,29.64) 65.03,29.05 66.04,28.04 66.04,20.62 64.19,18.77 SPI_DEBUG.6 64.19,16.18 63.9,15.9 61.69,15.9 61.09,15.29 61.09,11.94 60.12,10.97 57.07,10.97 55.68,9.58 55.68,8.05 55.91,7.82 56.41,7.82 56.92,8.33 R758.2 R759.2 C640.1 57.89,6.2 58.93,7.24 SPIROM1.7
SPI_MISO: length 9.8
  TOP w0.089: PCH1.BE30 64.95,42.85 64.95,41.48 65.86,40.56 65.86,38.89 66.27,38.48 67.51,38.48 68.4,37.6 R598.1 68.4,36.96
  TOP w0.102: R620.1 R611.1 68.4,36.96
SPI_MISO0: length 42.3
  TOP w0.102: R620.2 67.44,34.47 67.18,34.21 67.18,32.82 67.67,32.33 67.67,29.51 66.98,28.83 66.98,19.99 66.8,19.82 66.8,19.81 65.98,18.99 65.98,15.98 65.56,15.57 65.07,15.57 64.19,14.68 SPI_DEBUG.5 64.19,11 v1(63.73,10.54) ; SPIROM1.2 69.01,7.24 69.62,7.85 69.62,9.54 C637.1 70.69,10.62 71.45,10.62 71.78,10.29 v1(72.03,10.29)
  BOTTOM w0.102: v1(72.03,10.29) v2(70.97,10.29) 63.98,10.29 v1(63.73,10.54)
SPI_MOSI: length 9.6
  TOP w0.089: v3(64.39,40.28) 64.54,40.44 64.54,42.6 64.47,42.67 64.47,43.43 64.56,43.52 64.56,43.95 64.35,44.15 PCH1.BB29
  BOTTOM w0.089: 65.03,36.32 SR28.1 SR26.1 65.03,38.59 v2(65.2,38.76) 65.2,39.47 v3(64.39,40.28)
  BOTTOM w0.102: SR30.1 65.03,36.32
SPI_MOSI0: length 39.2
  TOP w0.102: v1(67.89,33.2) 68.17,32.92 68.17,29.26 67.49,28.58 67.49,19.76 66.73,19 SPI_DEBUG.10 66.73,15.88 66.12,15.27 66.12,12.09 v1(65.61,11.58) ; SPIROM1.5 58.8,9.78 58.24,9.22 57.17,9.22 C639.1 57.17,9.58 58.06,9.58 58.42,9.93 v1(58.42,10.46)
  BOTTOM w0.102: v1(67.89,33.2) 67.48,33.2 65.98,34.7 SR30.2 ; v1(58.42,10.46) 58.42,11.2 v2(58.62,11.4) 59.05,11.84 65.35,11.84 v1(65.61,11.58)
SRTCRST_L: length 12.7
  TOP w0.089: 52.33,36.96 52.99,37.62 53.49,37.62 55.45,39.57 55.83,39.57 56.03,39.78 56.03,40.94 55.7,41.28 55.7,42.6 55.55,42.75 55.55,43.67 55.47,43.75 55.47,43.95 55.26,44.16 PCH1.BB10
  TOP w0.102: 52.33,36.96 R604.2 51.86,36.93 50.5,35.56 C587.1
SSD_100M_N: length 145.6
  TOP w0.102: v3(52.57,62) 52.47,62.09 PCH1.E5 ; M2_2.53 98.66,17.92 98.48,18.11 96.59,18.11 96.36,18.34 90.23,18.34 88.81,16.92 85.07,16.92 84.54,16.38 84.3,16.38 v1(84.02,16.1) ; v1(29.01,56.13) 28.66,56.48 28.55,56.48 28.41,56.35 28.41,54.31 24.92,50.82 24.92,40.6 25.17,40.34 25.43,40.34 v1(25.78,40.7)
  BOTTOM w0.102: v1(29.01,56.13) 29.36,56.49 29.79,56.49 30.6,55.68 34.15,55.68 34.63,56.16 36.52,56.16 40.25,59.89 50.98,59.89 52.3,61.21 52.3,61.85 52.45,62 v3(52.57,62) ; v1(84.02,16.1) 83.69,16.43 81.41,16.43 80.49,17.35 72.96,17.35 72.37,16.76 69.18,16.76 68.06,17.88 58.11,17.88 57.62,18.36 55.45,18.36 54.69,17.6 52.95,17.6 50.83,19.73 50.83,21.35 50.28,21.89 48.57,21.89 48.01,21.34 42.46,21.34 41.67,22.12 40.78,22.12 38.68,24.23 32.29,24.23 31.71,23.65 29.45,23.65 29.14,23.34 27.04,23.34 26.03,24.35 26.03,28.5 26.52,28.98 26.52,34.64 24.84,36.31 24.84,39.96 25.19,40.31 25.4,40.31 25.78,40.69 v1(25.78,40.7)
SSD_100M_P: length 145.6
  TOP w0.102: M2_2.55 98.61,18.42 98.5,18.31 96.67,18.31 96.44,18.54 90.14,18.54 88.72,17.12 84.99,17.12 84.45,16.59 84.25,16.59 84.02,16.81 v1(84.02,17.02) ; v1(29.01,57.05) 28.64,56.69 28.47,56.69 28.21,56.43 28.21,54.4 24.71,50.9 24.71,40.51 25.09,40.14 25.43,40.14 v1(25.78,39.79) ; v3(51.8,61.68) 51.8,61.73 51.97,61.9 52.07,61.9 52.33,61.64 PCH1.G4
  BOTTOM w0.102: v1(84.02,17.02) 84.02,16.81 83.85,16.64 81.49,16.64 80.58,17.55 72.87,17.55 72.29,16.97 69.27,16.97 68.15,18.08 58.19,18.08 57.71,18.57 55.36,18.57 54.6,17.81 53.04,17.81 51.03,19.81 51.03,21.43 50.37,22.1 48.49,22.1 47.93,21.54 42.54,21.54 41.76,22.33 40.87,22.33 38.76,24.43 32.21,24.43 31.62,23.85 29.36,23.85 29.06,23.55 27.13,23.55 26.24,24.43 26.24,28.41 26.72,28.9 26.72,34.72 25.04,36.4 25.04,39.88 25.27,40.11 25.43,40.11 25.46,40.08 25.48,40.08 25.77,39.79 v1(25.78,39.79) ; v3(51.8,61.68) 51.99,61.68 52.1,61.57 52.1,61.3 50.89,60.1 40.16,60.1 36.43,56.36 34.54,56.36 34.06,55.88 30.68,55.88 29.87,56.69 29.36,56.69 v1(29.01,57.05)
SSD_DETECT: length 71.8
  TOP w0.089: PCH1.AG36 68.22,51.86 v3(67.87,51.51)
  TOP w0.102: R735.1 96.35,19.76 97.97,19.76 v1(98.15,19.94) ; v3(76.58,49.89) 76.83,49.89 77.75,48.97 78.69,48.97 80.92,46.74 81.33,46.74 82.09,45.97 83.36,45.97 83.82,45.52 83.82,44.63 84.56,43.89 85.29,43.89 85.42,44.02 86.39,44.02 86.92,43.48 89.66,43.48 91.08,44.91 91.08,47.65 92.68,49.25 95.33,49.25 v1(95.68,49.61)
  BOTTOM w0.089: v3(67.87,51.51) 68.47,52.11 70.42,52.11 70.89,51.64 71.93,51.64 72.21,51.36 75.54,51.36 76.58,50.32 v3(76.58,49.89)
  BOTTOM w0.102: v1(95.68,49.61) 96.09,49.2 96.09,44.55 95.58,44.04 95.58,32.05 v2(95.17,31.65) 95.17,30.58 98.78,26.97 98.78,20.57 v1(98.15,19.94)
SSD_DETECT_L: length 4
  TOP w0.102: R735.2 R734.1 97.43,21.92 M2_2.69
SUSACK_L: length 69.7
  TOP w0.089: v3(60.4,38.51) 60.43,38.51 61.19,39.27 61.19,41.15 60.58,41.76 60.58,42.31 60.11,42.78 60.11,43.61 60.02,43.71 60.02,43.94 59.81,44.15 PCH1.BB19
  TOP w0.102: R643.1 104.22,32.03 103.17,32.03 102.82,31.67 101.76,31.67 R642.1 R650.2 100.97,31.39 99.62,31.39 99.19,30.96 99.19,30.38 98.86,30.05 97.66,30.05 96.8,29.18 81.99,29.18 81.46,28.65 80.52,28.65 v1(80.06,29.11)
  BOTTOM w0.089: v3(60.4,38.51) 61.01,37.9 61.01,36.32
  BOTTOM w0.102: 61.01,36.32 60.48,35.79 60.48,34.19 60.12,33.83 60.12,30.81 v2(59.77,30.45) 60.1,30.12 60.1,27.25 62.28,25.07 64.77,25.07 65.51,25.81 69.11,25.81 69.7,26.39 78.41,26.39 80.06,28.04 v1(80.06,29.11)
SUSACK_R: length 2.9
  TOP w0.102: R643.2 105.43,32.21 106.66,33.44 U38.10
SUSCLK: length 99.6
  TOP w0.089: v3(57.89,48.26) 57.53,48.62 PCH1.AN15
  TOP w0.102: v1(55.83,29.49) 55.42,29.08 55.42,28.24 54.84,27.66 54.03,27.66 53.62,27.25 v1(53.62,26.24) ; R544.1 97.66,47.93 97.36,48.23 96.75,48.23 96.6,48.08 95.86,48.08 v1(95.61,47.83) 95.35,47.57 R540.1 R539.1 ; v1(94.74,33.76) 94.44,33.76 93.8,34.39 91.11,34.39 87.78,31.06 83.95,31.06 v1(83.77,31.24)
  BOTTOM w0.089: v3(57.89,48.26) 58.74,47.41 58.74,44.68 58.89,44.52 59,44.42 59,44.27 59,43.54 58.52,43.06 58.52,41.06 57.84,40.38 57.84,37.65 56.51,36.32
  BOTTOM w0.102: v1(95.61,47.83) 95.71,47.73 95.71,44.73 95.22,44.25 95.22,34.24 v1(94.74,33.76) ; 56.51,36.32 55.6,35.41 55.6,33.91 56.11,33.4 56.11,32.53 SC57.1 55.98,31.29 55.98,29.64 v1(55.83,29.49) ; v1(83.77,31.24) 83.77,28.37 79.45,24.05 70.66,24.05 69.95,23.34 69.95,21.64 69.72,21.41 61.9,21.41 61.04,22.28 56.16,22.28 53.75,24.69 v2(53.75,24.97) 53.75,26.11 v1(53.62,26.24)
SUSWARN_L: length 91
  TOP w0.089: v3(60.43,39.14) 60.6,39.14 60.99,39.52 60.99,41.07 60.39,41.67 60.39,42.23 59.73,42.89 59.73,43.13 59.68,43.18 PCH1.BD19
  TOP w0.102: v1(102.9,30.66) 102.41,31.14 R650.1 101.75,30.71 100.96,30.71 100.51,31.17 99.82,31.17 99.42,30.76 99.42,30.2 99.03,29.82 97.76,29.82 96.9,28.96 82.22,28.96 81.64,28.37 80.01,28.37 79.76,28.63 79.2,28.63 78.77,28.19 v1(78.77,27.48) ; v1(111.53,40.44) 111.35,40.44 110.86,40.93 R578.1 R577.1
  BOTTOM w0.089: v3(60.43,39.14) 61.24,38.33 61.24,36.32
  BOTTOM w0.102: v1(111.53,40.44) 111.28,40.69 104.06,40.69 102.97,41.78 100.89,41.78 100.51,41.4 100.51,39.07 v2(100.94,38.63) 101.55,38.02 101.55,32 v1(102.9,30.66) ; v1(78.77,27.48) 71.75,27.48 71.17,26.9 69.88,26.9 69.04,26.06 65.4,26.06 64.64,25.3 62.38,25.3 60.32,27.36 60.32,28.17 61.16,29.01 61.16,30.07 60.35,30.89 60.35,33.73 60.71,34.09 60.71,35.66 61.24,36.19 61.24,36.32
SUSWARN_R: length 4.4
  TOP w0.178: U38.55 112.59,39.48 v2(112.17,39.9)
  TOP w0.203: v2(112.17,39.9) 112.17,40.59 110.88,41.88 R578.2
SW_DIS_ME: length 7
  TOP w0.102: Q21.E 4.98,110.11 5.66,110.79 RJ3.3 v1(8.81,110.79)
SYS_FAN_P3: length 10.6
  TOP w0.254: R525.2 R527.1 183.9,49.18 SYS_FAN.3
  TOP w0.508: D18.P 176.25,47.98 177.45,49.18 R525.2
SYS_FAN_P4: length 5.7
  TOP w0.254: R538.2 184.98,47.78 SYS_FAN.4
SYS_THERM: length 12.7
  TOP w0.178: 117.65,36.51 117.38,36.24 U38.46
  TOP w0.254: 117.65,36.51 118.58,37.44 121.39,37.44 v2(122.66,38.71) 123.39,39.44 R586.2 R587.2 C575.2 C581.1
THERMAL_SD: length 58.5
  TOP w0.089: PCH1.AE44 72,52.5 72.24,52.73 72.94,52.73 74.14,51.54 77.53,51.54
  TOP w0.102: v1(101.88,39.88) 101.42,39.88 100.36,40.94 100.36,41.71 100.86,42.21 100.86,47.62 98.2,50.29 92.94,50.29 90.63,47.98 90.63,45.21 89.36,43.94 87.15,43.94 85.78,45.31 85.78,46.58 85.5,46.86 84.84,46.86 R545.1 83.79,46.35 81,49.15 80.09,49.15 77.7,51.54 77.53,51.54 ; U38.63 109.39,37.02 v1(109.4,37.01)
  BOTTOM w0.102: v1(109.4,37.01) 105.97,40.44 v2(102.57,40.44) 102.44,40.44 v1(101.88,39.88)
TP_AE17: length 2.8
  TOP w0.089: PCH1.AE17 58.07,53.35 58.07,53.87 58.3,54.11 v4(58.94,54.11)
  BOTTOM w0.089: STP19.1 58.95,54.13 v4(58.94,54.11)
TP_AF17: length 3.3
  TOP w0.089: v3(57.91,51.36) 57.91,51.61 PCH1.AF17
  BOTTOM w0.089: STP52.1 59.13,50.04 57.91,51.26 v3(57.91,51.36)
TP_AG14: length 3.4
  TOP w0.089: PCH1.AG14 56.9,51.64 56.9,50.59 57.22,50.27 v3(57.92,50.27)
  BOTTOM w0.089: v3(57.92,50.27) 58.17,50.01 STP21.1
TP_AG15: length 1.3
  TOP w0.089: v3(57.97,52.44) 57.76,52.23 PCH1.AG15
  BOTTOM w0.089: STP20.1 57.89,52.87 57.89,52.52 v3(57.97,52.44)
TP_AN17: length 1.3
  TOP w0.089: PCH1.AN17 v3(58.15,48.87)
  BOTTOM w0.089: v3(58.15,48.87) 58.35,48.87 STP23.1
TP_AR19: length 1.6
  TOP w0.089: v3(59.34,48.19) PCH1.AR19
  BOTTOM w0.089: STP57.1 60.22,48.19 v3(59.34,48.19)
TP_AZA_PLLMON_N: length 4
  TOP w0.089: PCH1.BE2 49.38,42.91 v1(48.92,42.44)
  BOTTOM w0.089: v1(48.92,42.44) 48.34,41.86 STP71.1
TP_AZA_PLLMON_P: length 4.6
  TOP w0.089: v1(48.74,43.18) 48.82,43.26 PCH1.BD1
  BOTTOM w0.089: STP69.1 47.4,41.83 v1(48.74,43.18)
TP_CL_CLK: length 20.7
  TOP w0.089: PCH1.AV2 51.03,46.35 50.57,46.35 49.66,45.44 45.06,45.44
  TOP w0.102: TP16.1 35.74,40.72 35.99,40.46 37.74,40.46 37.97,40.69 38.79,40.69 39.89,41.8 39.89,43.24 42.09,45.44 45.06,45.44
TP_CL_DATA: length 19.7
  TOP w0.089: 45.06,45.21 45.08,45.19 49.71,45.19 50.62,46.1 51.38,46.1 PCH1.AV3
  TOP w0.102: TP17.1 35.69,40.21 37.82,40.21 38.07,40.46 38.89,40.46 40.13,41.71 40.13,43.15 42.19,45.21 45.06,45.21
TP_CL_RST_L: length 20.1
  TOP w0.089: PCH1.AW2 51.05,45.57 50.65,45.57 49.83,44.75 45.06,44.75
  TOP w0.102: TP18.1 35.43,38.35 36.19,39.12 38.25,39.12 40.59,41.45 40.59,42.95 42.39,44.75 45.06,44.75
TP_DMIC_CLK_0: length 11.9
  TOP w0.089: v3(67.1,50.07) PCH1.AJ35
  BOTTOM w0.089: STP58.1 76.68,46.86 72.82,46.86 72.26,47.42 71.32,47.42 70.03,48.72 68.45,48.72 v3(67.1,50.07)
TP_DMIC_CLK_1: length 10.4
  TOP w0.089: v3(74.12,47.5) 74.12,48.51 72.67,49.96 72.67,50.3 72.24,50.73 72.24,50.95 72.12,51.06 71.28,51.06 71.18,50.97 PCH1.AJ42
  BOTTOM w0.089: STP59.1 78.05,47.27 74.35,47.27 v3(74.12,47.5)
TP_DMIC_DATA_0: length 12.4
  TOP w0.089: 79.22,46.58 77.8,46.58 76.89,47.5 75.41,47.5 72.87,50.04 72.87,50.37 72.44,50.8 72.44,51.01 72.1,51.35 PCH1.AH44
  TOP w0.102: 79.22,46.58 79.58,46.58 81.2,44.96 TP13.1
TP_DMIC_DATA_1: length 10.1
  TOP w0.089: PCH1.AJ38 v3(68.63,50.07)
  BOTTOM w0.089: v3(68.63,50.07) 69.24,50.69 70.44,50.69 71.77,49.35 75.97,49.35 STP55.1
TP_GPP_A12: length 7.9
  TOP w0.089: TP19.1 59.74,37.77 59.74,41.46 59.26,41.93 59.26,42.45 59.08,42.64 59.08,43.18 58.92,43.34 58.92,44 58.81,44.11 PCH1.BB17
TP_GPP_A16: length 1.5
  TOP w0.089: v3(58.01,47.5) 58.35,47.83 PCH1.AR17
  BOTTOM w0.089: v3(58.01,47.5) 57.84,47.5 STP25.1
TP_GPP_B_1: length 10
  TOP w0.089: v3(63.85,49.74) 63.67,49.91 PCH1.AL27
  BOTTOM w0.089: v3(63.85,49.74) 64.19,49.4 64.19,48.51 64.64,48.06 64.64,44.83 64.57,44.75 64.57,43.76 65.66,42.66 65.66,41.88 STP70.1
TP_GPP_B_11: length 1.6
  TOP w0.102: v3(62.76,48.95) PCH1.AN24
  BOTTOM w0.089: v3(62.76,48.95) 63.04,48.66 STP56.1
TP_GPP_E5: length 13.3
  TOP w0.089: 79.22,48.87 78.45,49.64 78.45,49.85 77.44,50.85 76.94,50.85 ; PCH1.AG43 71.71,51.93 71.85,52.07 72.73,52.07 73.95,50.85 75.54,50.85
  TOP w0.102: 75.54,50.85 76.94,50.85 ; 79.22,48.87 81.1,46.99 81.97,46.99 TP12.1
TP_GPP_E6: length 10.7
  TOP w0.089: PCH1.AE45 72.91,52.5 74.1,51.3 77.44,51.3 ; 78.94,49.94 79.22,49.66
  TOP w0.102: 78.94,49.94 77.58,51.3 77.44,51.3 ; TP11.1 80.87,48.01 79.22,49.66
TP_GPP_F7: length 8.1
  TOP w0.089: v1(77.57,56.26) 77.1,56.26 75.78,54.93 75.13,54.93 74.55,54.36 71.86,54.36 71.71,54.2 PCH1.AB43
  BOTTOM w0.089: STP47.1 76.53,56.26 v1(77.57,56.26)
TP_GPP_F8: length 7.3
  TOP w0.089: v3(67.87,54.91) PCH1.AB36
  BOTTOM w0.089: STP50.1 73.57,54.17 68.61,54.17 v3(67.87,54.91)
TP_GPP_F9: length 3.9
  TOP w0.089: v3(69.39,54.91) PCH1.AB39
  BOTTOM w0.089: v3(69.39,54.91) 69.94,54.36 71.86,54.36 STP49.1
TP_GPP_F23: length 8.1
  TOP w0.089: v1(77.5,59.84) 77.5,59.51 75.38,57.4 74.71,57.4 73.74,56.43 72.16,56.43 72.11,56.38 PCH1.V44
  BOTTOM w0.089: STP43.1 77.67,59.66 v1(77.5,59.84)
TP_GPP_G8: length 5.9
  TOP w0.089: v1(75.72,59.89) 75.72,59.49 74.83,58.6 74.24,58.6 73.3,57.66 PCH1.R44
  BOTTOM w0.089: STP44.1 76.3,59.89 v1(75.72,59.89)
TP_GPP_G9: length 15.9
  TOP w0.089: 79.22,62.51 77.57,62.51 76.17,61.11 76.17,59.66 74.9,58.39 74.32,58.39 73.39,57.47 72.14,57.47 72.1,57.43 71.69,57.43 PCH1.R43
  TOP w0.102: v1(82.63,63.75) 81.38,62.51 79.22,62.51
  BOTTOM w0.102: STP41.1 83.26,64.39 v1(82.63,63.75)
TP_GPP_G10: length 2
  TOP w0.089: PCH1.U39 69.27,57.05 v3(69.27,57.38)
  BOTTOM w0.089: v3(69.27,57.38) 69.27,57.48 STP45.1
TP_GPP_G11: length 9.6
  TOP w0.089: PCH1.N42 71.12,58.78 71.32,58.98 71.63,58.98 71.73,59.08 72.57,59.08 73.74,60.25 73.74,61.16 75.54,62.97 75.54,63.88 v1(76.1,64.44)
  BOTTOM w0.089: STP40.1 76.5,64.85 v1(76.1,64.44)
TP_GPP_G_17: length 8.9
  TOP w0.089: v1(76.68,63.68) 76.68,63.09 74.18,60.59 74.18,60.03 72.83,58.69 72.03,58.69 PCH1.N44
  BOTTOM w0.089: STP42.1 75.41,63.68 v1(76.68,63.68)
TP_GPP_I3: length 6.2
  TOP w0.089: v4(52.34,44.89) 52.05,44.6 PCH1.BA4
  BOTTOM w0.089: v4(52.34,44.89) 52.05,44.6 48.16,44.6 STP65.1
TP_L_BKLTCTL: length 11
  TOP w0.089: v3(67.87,55.95) PCH1.W36
  BOTTOM w0.089: v3(67.87,55.95) 68.32,55.5 76.84,55.5
  BOTTOM w0.102: 76.84,55.5 77.57,55.5 STP48.1
TP_L_BKLTEN: length 7
  TOP w0.089: v3(67.1,55.95) PCH1.W35
  BOTTOM w0.089: v3(67.1,55.95) 67.74,56.59 70.76,56.59 71.07,56.29 72.59,56.29 STP46.1
TP_L_VDDEN: length 22.9
  TOP w0.089: 79.22,60.14 75.16,56.08 74.59,56.08 74.09,55.58 72.14,55.58 72.11,55.61 71.28,55.61 71.18,55.51 PCH1.W42
  TOP w0.102: TP8.1 91.01,61.21 82.98,61.21 82.5,60.73 79.81,60.73 79.22,60.14
TP_PCH_AB13: length 1.5
  TOP w0.089: PCH1.AB13 56.06,54.77 v3(56.06,55.03)
  BOTTOM w0.089: STP18.1 55.78,55.45 56.06,55.17 v3(56.06,55.03)
TP_PCH_AR22: length 1.6
  TOP w0.089: PCH1.AR22 61.42,47.32 v3(61.42,47.22)
  BOTTOM w0.089: v3(61.42,47.22) 61.42,46.58 STP61.1
TP_VGA: length 8.8
  TOP w0.102: U38.5 106.48,35.44 106.17,35.13 105.49,35.13 104.88,35.74 103.02,35.74 102.41,35.13 101.78,35.13 R616.1 101.1,35.56 TP20.1
TPM_P5: length 4
  TOP w0.102: R708.1 C618.2 88.72,25.28 LPC_DEBUG.5
TPM_P6: length 6.7
  TOP w0.102: LPC_DEBUG.6 88.72,21.21 87.6,22.33 87.6,25.3 R707.2 R706.2
TPM_P15: length 2.3
  TOP w0.102: R719.1 76.02,24.31 LPC_DEBUG.15
TPM_P18: length 5
  TOP w0.102: R718.1 74.27,24.05 74.42,23.9 74.42,22.35 73.48,21.41 LPC_DEBUG.18
TPM_P19: length 3.2
  TOP w0.102: LPC_DEBUG.19 70.94,24.82 R715.1 R716.1
TPM_RSV2: length 5.9
  TOP w0.102: R717.2 73.13,24.13 72.24,23.24 72.24,20.98 71.63,20.37 LPC_DEBUG.20
UGATE1_A: length 46.5
  TOP w0.203: v1(161.14,214.25) 161.79,213.6 U19.27
  TOP w0.508: v1(128.57,198.73) 129.67,198.73 130.4,197.99 R221.1
  BOTTOM w0.508: v1(128.57,198.73) v2(128.57,200.28) 128.7,200.41 128.7,203.88 130.63,205.8 141.68,205.8 144.11,208.23 146.1,208.23 150.34,212.47 157.2,212.47 158.5,213.77 160.78,213.77 161.14,214.12 v1(161.14,214.25)
UGATE1_B: length 105.8
  TOP w0.203: U19.36 161.61,210 160.91,209.3 v1(160.63,209.3)
  TOP w0.508: v1(153.9,195.33) 154.84,195.33 155.17,195 175.82,195 177.04,193.78 v1(177.04,192.86)
  TOP w0.635: R293.1 v1(190.22,148.97)
  BOTTOM w0.508: v1(177.04,192.86) 177.04,188.32 178.04,187.31 190.8,187.31 194.84,183.27 194.84,156.77 190.22,152.15 v2(190.22,151.05) v1(190.22,148.97) ; v1(160.63,209.3) 160.63,208.43 158.05,205.85 158.05,205.82 157.16,204.93 157.16,203.84 152.88,199.56 152.88,196.34 v1(153.9,195.33)
UGATE1A_G: length 3.6
  TOP w0.508: R221.2 128.5,196.85 R222.2 126.72,197.01 QCH1.G
UGATE1B_G: length 3.9
  TOP w0.635: R290.2 186.7,151.29 QCGH1.G 187.17,150.81 187.17,149.23 R293.2
UGATE1C_G: length 3.3
  TOP w0.635: R227.2 109.54,197.52 R218.2 109.7,198.15 QCSH1.G
UGATE2_A: length 28
  TOP w0.203: v1(160.63,212.04) 160.67,212 U19.31
  TOP w0.635: R220.1 v1(146.28,198.37)
  BOTTOM w0.508: v1(160.63,212.04) 160.63,211.48 157.25,208.1 151.97,208.1 148.03,204.17 145.79,204.17 144.91,203.28 144.91,199.75 v2(145.44,199.21) v1(146.28,198.37)
UGATE2_B: length 14.1
  TOP w0.254: v1(189.84,140.72) 189.97,140.84 190.04,140.84 190.36,141.16 U27.1
  TOP w0.635: 187.93,131.44 v1(187.93,129.92)
  BOTTOM w0.635: v1(187.93,129.92) 187.93,133.35 188.82,134.24 v2(188.82,136.63) 188.82,139.7 v1(189.84,140.72)
UGATE2A_G: length 3.8
  TOP w0.635: R220.2 144.25,196.85 R223.2 142.47,197.01 QCH2.G
UGATE2B_G: length 3.9
  TOP w0.635: R303.2 185.58,133.6 QCGH2.G 186.86,132.84 186.16,132.14 R304.2
UGATE3_A: length 14.2
  TOP w0.254: U24.1 188.96,176.6 188.64,176.28 188.57,176.28 v1(188.44,176.15)
  TOP w0.635: R278.1 186.41,165.35 v1(185.52,166.24)
  BOTTOM w0.635: v1(185.52,166.24) 188.82,169.55 v2(188.82,173.51) 188.82,175.77 v1(188.44,176.15)
UGATE3A_G: length 3.5
  TOP w0.635: R278.2 186.86,167.2 QCH3.G 185.55,169.04 R277.2
USB2_COMP: length 13.1
  TOP w0.102: PCH1.AG3 51.72,51.54 51.43,51.83 51.03,51.83 50.91,51.94 49.2,51.94 48.74,52.4 46.35,52.4 45.82,52.93 43.21,52.93 40.67,55.47 R467.1
USB2_ID: length 16.8
  TOP w0.102: R466.1 36.32,55.65 37.19,54.79 40.61,54.79 40.63,54.76 40.64,54.76 42.98,52.43 45.77,52.43 46.25,51.94 48.59,51.94 48.86,51.68 50.89,51.68 50.94,51.63 50.95,51.63 51.03,51.54 PCH1.AG2
USB2_VBUSSENSE: length 24.9
  TOP w0.089: v3(55.02,52.51) 54.92,52.66 PCH1.AD10
  TOP w0.102: v3(46.53,52.96) 46,53.49 43.38,53.49 40.51,56.36 34.12,56.36 R465.1
  BOTTOM w0.089: v3(46.53,52.96) 48.49,52.96 48.89,52.55 50.01,52.55 51.02,53.56 53.32,53.56 53.92,52.96 54.56,52.96 v3(55.02,52.51)
USB3_RX_N1: length 81.2
  TOP w0.102: v1(28.47,62.38) 28.17,62.69 27.61,62.69 22.66,57.73 22.66,39.34 20.07,36.75 18.03,36.75 17.81,36.53 CHOKE17.1 ; v1(41.5,68.15) 41.27,67.92 41.27,67.59 41.4,67.46 42.01,67.46 42.39,67.84 42.39,71.66 44.04,73.31 44.04,75.16 45.59,76.71 47.86,76.71 52.07,72.5 52.07,66.83 53.95,64.95 53.95,64.35 PCH1.B7
  BOTTOM w0.102: v1(41.5,68.15) 41.27,67.92 41.27,67.56 41.02,67.31 38.93,67.31 38.55,67.69 37.1,67.69 35.83,68.96 33.16,68.96 30.76,66.57 30.76,64.3 29.17,62.71 28.8,62.71 v1(28.47,62.38)
USB3_RX_N1_R: length 26.4
  TOP w0.102: USB3F1.2 8.21,47.44 8.02,47.24 7.53,47.24 7.14,46.85 7.14,43.69 6.54,43.1 5.43,43.1 4.5,42.16 4.5,37.91 5.43,36.98 6.82,36.98 7.34,37.51 7.34,38.51 7.8,38.96 8.64,38.96 10.88,36.72 11.4,36.72 11.55,36.57 D20.7 D20.4 13.35,36.57 13.51,36.72 14.66,36.72 14.9,36.47 RN10.6
USB3_RX_N2: length 72.3
  TOP w0.102: CHOKE18.1 17.74,34.75 17.88,34.9 19.39,34.9 23.39,38.9 23.39,52.98 25,54.58 v2(25.48,54.58) 25.48,55.06 25.89,55.47 26.35,55.47 v1(26.6,55.22) ; v1(52.66,67.94) 52.91,67.69 53.16,67.69 53.39,67.46 53.39,66.24 54.46,65.17 54.46,64.38 54.55,64.29 54.55,63.98 54.23,63.65 PCH1.C8
  BOTTOM w0.102: v1(26.6,55.22) 26.88,55.5 27.18,55.5 28.47,54.2 36.5,54.2 40.82,58.52 53.29,58.52 54.48,59.72 54.48,66.89 53.74,67.63 52.97,67.63 v1(52.66,67.94)
USB3_RX_N2_R: length 25.8
  TOP w0.102: RN10.2 14.78,34.85 14.48,35.15 13.49,35.15 13.4,35.07 D20.1 D20.10 11.73,35.07 11.6,35.2 10.69,35.2 9.01,36.88 7.83,36.88 7.34,36.39 7.34,35.42 6.87,34.95 4.87,34.95 3.81,36.01 3.81,44.37 4.81,45.38 5.57,45.38 USB3F1.18
USB3_RX_N3: length 195.3
  TOP w0.102: v1(42.25,73.54) 42.25,74.87 44.77,77.39 48.21,77.39 53.44,72.16 53.44,68.33 53.95,67.83 53.95,66.42 55.09,65.28 55.09,64.51 54.85,64.26 PCH1.B10 ; CHOKE11.1 93.66,218.94 94.04,218.56 94.04,217.97 92.46,216.39 92.46,214.99 v1(92.23,214.76)
  BOTTOM w0.102: v1(92.23,214.76) 92.46,214.53 92.46,214.2 92.07,213.82 90.96,213.82 78.84,201.7 78.84,197.46 66.45,185.06 65.15,185.06 48.06,167.97 48.06,116.03 40.49,108.46 40.49,81.65 41.63,80.51 41.63,74.59 42.25,73.97 v1(42.25,73.54)
USB3_RX_N3_R: length 11.7
  TOP w0.102: RN6.2 93.75,221.69 94.11,222.05 94.11,222.66 93.97,222.79 U12.1 U12.10 93.97,224.63 94.11,224.76 94.11,225.98 95.2,227.08 97.66,227.08 98.48,227.89 98.48,228.4 98.23,228.64 USB3X2.14
USB3_RX_N4: length 205.9
  TOP w0.102: PCH1.E11 55.39,62.61 55.63,62.61 v3(55.96,62.28) ; CHOKE12.1 95.43,219.02 95.77,218.68 95.77,218.55 94.01,216.79 94.01,214.05 93.78,213.82 v1(93.7,213.82)
  BOTTOM w0.102: v3(55.96,62.28) 56.27,62.02 56.37,62.03 56.56,62.03 56.92,61.67 59.36,61.67 60.02,61.01 60.62,61.01 60.91,61.3 60.91,63.92 60.5,64.33 60.5,67.12 55.64,71.98 54.15,71.98 53.34,72.8 51.23,72.8 v2(50.9,72.47) 50.57,72.8 49.82,72.8 48.06,71.04 45.79,71.04 43.84,72.99 43.84,79.32 41.17,81.98 41.17,108.16 48.74,115.73 48.74,167.64 65.48,184.38 66.78,184.38 79.53,197.13 79.53,201.38 91.28,213.13 93.74,213.13 93.98,213.37 93.98,213.64 93.8,213.82 v1(93.7,213.82)
USB3_RX_N4_R: length 16
  TOP w0.102: USB3X2.5 98.31,231.84 98.56,231.59 98.56,231.15 99.35,230.36 99.35,230.08 100.48,228.95 100.48,228.09 100.05,227.66 99.28,227.66 98.01,226.39 96.18,226.39 95.63,225.84 95.63,224.74 95.47,224.58 U12.7 U12.4 95.47,222.66 95.63,222.5 95.63,222.13 95.38,221.88 RN6.6
USB3_RX_P1: length 81
  TOP w0.102: CHOKE17.4 17.69,37.38 18.11,36.96 19.99,36.96 22.45,39.42 22.45,57.82 27.53,62.89 28.3,62.89 28.47,63.07 v1(28.47,63.3) ; v1(40.61,68.1) 40.89,68.1 41.07,67.92 41.07,67.51 41.32,67.26 42.1,67.26 42.6,67.76 42.6,71.58 44.25,73.23 44.25,75.07 45.68,76.5 47.78,76.5 51.87,72.42 51.87,66.74 53.75,64.86 53.75,64.6 PCH1.A7
  BOTTOM w0.102: v1(40.61,68.1) 40.89,68.1 41.07,67.92 41.07,67.65 40.94,67.51 39.01,67.51 38.63,67.89 37.18,67.89 35.91,69.16 33.07,69.16 30.56,66.65 30.56,64.39 29.08,62.92 28.65,62.92 28.47,63.09 v1(28.47,63.3)
USB3_RX_P1_R: length 26.4
  TOP w0.102: RN10.8 14.83,37.29 14.47,36.92 13.49,36.92 13.34,37.07 D20.5 D20.6 11.54,37.07 11.4,36.92 10.96,36.92 8.72,39.17 7.71,39.17 7.14,38.59 7.14,37.59 6.73,37.19 5.51,37.19 4.7,38 4.7,42.08 5.51,42.89 6.63,42.89 7.34,43.6 7.34,46.77 7.61,47.04 8.25,47.04 8.51,46.79 8.51,46.32 USB3F1.3
USB3_RX_P2: length 71.9
  TOP w0.102: PCH1.B8 54.31,64.25 54.26,64.3 54.26,65.09 53.19,66.16 53.19,67.38 53.08,67.49 52.81,67.49 52.66,67.34 v1(52.66,67.11) ; CHOKE18.4 17.69,35.6 18.19,35.1 19.3,35.1 23.19,38.99 23.19,53.06 23.57,53.44 v2(23.57,53.92) 24.05,53.92 25.81,55.68 26.42,55.68 26.67,55.93 26.67,56.22 v1(26.6,56.29)
  BOTTOM w0.102: v1(52.66,67.11) 52.98,67.43 53.65,67.43 54.28,66.8 54.28,59.8 53.2,58.72 40.73,58.72 36.42,54.41 28.56,54.41 27.26,55.7 26.7,55.7 26.49,55.91 26.49,56.18 v1(26.6,56.29)
USB3_RX_P2_R: length 26.1
  TOP w0.102: USB3F1.17 6.38,44.18 6.38,44.96 6.16,45.17 4.9,45.17 4.01,44.29 4.01,36.09 4.95,35.15 6.78,35.15 7.14,35.51 7.14,36.47 7.75,37.08 9.09,37.08 10.77,35.41 11.53,35.41 11.69,35.57 D20.9 D20.2 13.33,35.57 13.54,35.36 14.5,35.36 14.81,35.66 RN10.4
USB3_RX_P3: length 195
  TOP w0.102: CHOKE11.4 94.51,218.92 94.24,218.65 94.24,217.89 92.66,216.31 92.66,214.99 92.86,214.78 v1(93.07,214.78) ; PCH1.A9 54.89,64.71 54.89,65.19 53.75,66.34 53.75,67.74 53.24,68.25 53.24,72.08 48.12,77.19 44.86,77.19 42.45,74.79 42.45,74.08 42.6,73.94 42.77,73.94 43.1,74.27 v1(43.1,74.32)
  BOTTOM w0.102: v1(93.07,214.78) 92.91,214.78 92.66,214.53 92.66,214.11 92.16,213.61 91.04,213.61 79.04,201.62 79.04,197.38 66.53,184.86 65.24,184.86 48.26,167.89 48.26,115.94 40.69,108.37 40.69,81.74 41.83,80.59 41.83,74.68 42.57,73.94 42.72,73.94 v1(43.1,74.32)
USB3_RX_P3_R: length 12
  TOP w0.102: RN6.4 94.56,221.72 94.31,221.97 94.31,222.6 94.47,222.76 U12.2 U12.9 94.47,224.58 94.31,224.74 94.31,225.9 95.28,226.87 97.75,226.87 98.68,227.8 98.68,228.57 98.88,228.78 99.51,228.78 USB3X2.15
USB3_RX_P4: length 206
  TOP w0.102: v3(56.03,61.51) 55.82,61.72 PCH1.G11 ; v1(94.44,213.82) 94.21,214.05 94.21,216.7 95.97,218.47 95.97,218.71 96.28,219.02 CHOKE12.4
  BOTTOM w0.102: v3(56.03,61.51) 56.29,61.82 56.38,61.83 56.48,61.83 56.84,61.47 59.28,61.47 59.94,60.81 60.71,60.81 61.11,61.21 61.11,64.01 60.71,64.41 60.71,67.21 55.73,72.19 54.24,72.19 53.42,73 52.83,73 v2(52.5,73.33) 52.17,73 49.73,73 47.98,71.25 45.87,71.25 44.04,73.08 44.04,79.4 41.38,82.07 41.38,108.08 48.95,115.65 48.95,167.56 65.57,184.18 66.86,184.18 79.73,197.05 79.73,201.3 91.36,212.93 93.83,212.93 94.18,213.28 94.18,213.56 v1(94.44,213.82)
USB3_RX_P4_R: length 16
  TOP w0.102: USB3X2.6 99.06,231.84 98.76,231.55 98.76,231.23 99.55,230.45 99.55,230.17 100.69,229.03 100.69,228.01 100.13,227.46 99.36,227.46 98.09,226.19 96.27,226.19 95.83,225.76 95.83,224.75 95.97,224.61 U12.6 U12.5 95.97,222.69 95.83,222.55 95.83,222.12 96.19,221.77 RN6.8
USB3_TX_N1: length 78.7
  TOP w0.102: v1(28.47,65.79) 28.22,65.53 27.32,65.53 21.74,59.95 21.74,39.86 21.11,39.23 20.63,39.23 C572.1 ; PCH1.C11 55.6,63.85 55.6,64.25 55.54,64.3 55.54,65.82 54.64,66.73 54.64,68.12 54.2,68.55 54.2,72.37 48.42,78.16 44.47,78.16 40.94,74.63 40.94,69.88 40.28,69.22 40.06,69.22 v1(39.78,69.49)
  BOTTOM w0.102: v1(28.47,65.79) 28.7,65.56 29.25,65.56 29.72,66.02 29.72,67.03 32.54,69.85 36.19,69.85 37.46,68.58 38.51,68.58 39.14,69.22 39.5,69.22 v1(39.78,69.49)
USB3_TX_N1_C: length 2.7
  TOP w0.102: CHOKE16.4 17.88,39.62 18.08,39.42 18.44,39.42 18.77,39.09 19.05,39.09 19.31,39.35 C572.2
USB3_TX_N1_R: length 8.8
  TOP w0.102: USB3F1.5 8.21,41.35 8.36,41.21 8.94,41.21 10.46,39.69 11.5,39.69 11.65,39.84 D19.4 D19.7 13.45,39.84 13.61,39.67 13.89,39.67 14.17,39.4 14.55,39.4 14.78,39.62 CHOKE16.3
USB3_TX_N2: length 77
  TOP w0.102: v1(28.45,67.28) 28.13,67.6 28.13,67.59 26.58,67.59 21.23,62.25 21.23,41.48 21.01,41.25 20.75,41.25 C569.1 ; PCH1.B12 55.97,64.16 55.75,64.39 55.75,64.68 55.77,64.71 55.77,66.04 54.97,66.84 54.97,68.27 54.69,68.55 54.69,72.59 48.63,78.64 44.05,78.64 40.34,74.92 40.34,71.2 39.04,69.9 38.79,69.9 v1(38.46,69.57)
  BOTTOM w0.102: v1(28.45,67.28) 28.83,67.67 29.17,67.67 31.89,70.38 36.8,70.38 37.36,69.82 38.2,69.82 v1(38.46,69.57)
USB3_TX_N2_C: length 2.6
  TOP w0.102: CHOKE15.1 17.58,40.55 17.88,40.84 18.19,40.84 18.56,41.21 18.87,41.21 C569.2
USB3_TX_N2_R: length 16.1
  TOP w0.102: CHOKE15.2 14.83,40.55 14.43,40.94 13.56,40.94 13.45,40.84 D19.9 D19.2 11.65,40.84 11.5,40.98 11.21,40.98 9.2,43 7.95,43 7.34,42.39 7.34,41.35 6.96,40.97 5.74,40.97 5.38,40.61 5.38,39.3 5.7,38.99 6.25,38.99 6.43,39.17 6.43,39.81 USB3F1.15
USB3_TX_N3: length 195.5
  TOP w0.102: v1(95.86,214.84) 96.04,214.84 96.24,215.04 96.24,215.47 95.78,215.93 C88.1 ; v1(38.4,89.28) 38.05,89.64 37.8,89.64 37.41,89.25 37.41,85.89 43.75,79.55 49,79.55 55.58,72.98 55.58,68.76 55.71,68.62 55.71,67.12 56.41,66.43 56.41,63.99 56.54,63.85 PCH1.C13
  BOTTOM w0.102: v1(95.86,214.84) 96.12,214.84 96.29,215.01 96.29,215.27 95.26,216.29 91.76,216.29 77.67,202.21 77.67,197.97 65.94,186.23 64.64,186.23 46.86,168.45 46.86,121.34 45.52,119.99 45.52,115.16 39.27,108.92 39.27,89.91 39,89.64 38.76,89.64 v1(38.4,89.28)
USB3_TX_N3_C: length 4.5
  TOP w0.102: C88.2 95.96,217.37 95.96,217.61 96.49,218.14 97.69,218.14 98.17,218.62 98.17,218.82 97.92,219.07 CHOKE9.1
USB3_TX_N3_R: length 13.9
  TOP w0.102: USB3X2.17 104.46,228.64 104.83,228.27 104.83,227.63 104.04,226.85 99.56,226.85 98.56,225.85 98.56,224.46 98.42,224.32 U13.10 U13.1 98.42,222.61 98.5,222.53 98.5,222.35 98.3,222.15 98.3,221.97 97.92,221.6 CHOKE9.2
USB3_TX_N4: length 195.5
  TOP w0.102: C90.1 97.94,215.93 98.15,215.72 98.15,215.11 v1(97.76,214.73) ; PCH1.A14 56.95,64.6 56.95,66.61 56.26,67.29 56.26,73.31 49.33,80.24 49.29,80.24 44.22,80.24 40.87,83.59 40.87,85.05 40.04,85.88 39.28,85.88 v1(39.01,86.16)
  BOTTOM w0.102: v1(97.76,214.73) 97.94,214.73 98.09,214.58 98.09,213.94 97.69,213.54 96.1,213.54 93.84,215.8 91.97,215.8 78.16,201.99 78.16,197.76 66.14,185.75 64.85,185.75 47.35,168.25 47.35,121.01 46,119.67 46,114.96 39.78,108.74 39.78,86.11 39.54,85.88 39.28,85.88 v1(39.01,86.16)
USB3_TX_N4_C: length 4.3
  TOP w0.102: C90.2 98.12,217.34 98.12,217.55 98.4,217.83 99.54,217.83 99.97,218.26 99.97,218.54 99.7,218.81 CHOKE10.1
USB3_TX_N4_R: length 17.2
  TOP w0.102: USB3X2.8 104.13,231.84 105.05,230.91 105.45,230.91 106.45,229.91 106.45,228.05 104.34,225.93 100.91,225.93 100.08,225.1 100.08,224.41 99.92,224.25 U13.7 U13.4 99.92,222.56 100.08,222.4 100.08,222.08 99.7,221.71 CHOKE10.2
USB3_TX_P1: length 78.7
  TOP w0.102: v1(39.78,68.58) 39.78,68.76 40.03,69.01 40.37,69.01 41.15,69.79 41.15,74.55 44.55,77.95 48.34,77.95 54,72.29 54,68.47 54.43,68.04 54.43,66.64 55.34,65.73 55.34,64.22 55.36,64.2 PCH1.B11 ; C578.1 20.26,38.75 20.54,39.03 21.2,39.03 21.95,39.78 21.95,59.87 27.41,65.33 28.17,65.33 28.47,65.02 v1(28.47,64.87)
  BOTTOM w0.102: v1(28.47,64.87) 28.47,65.07 28.75,65.35 29.34,65.35 29.92,65.94 29.92,66.95 32.62,69.65 36.11,69.65 37.38,68.38 38.59,68.38 39.23,69.01 39.57,69.01 39.78,68.81 v1(39.78,68.58)
USB3_TX_P1_C: length 2.8
  TOP w0.102: C578.2 19.31,38.65 19.08,38.89 18.69,38.89 18.36,39.22 18.08,39.22 17.63,38.77 CHOKE16.1
USB3_TX_P1_R: length 9.5
  TOP w0.102: USB3F1.6 7.91,40.33 7.91,40.85 8.06,41.01 8.85,41.01 10.38,39.48 11.5,39.48 11.65,39.34 D19.5 D19.6 13.53,39.34 13.67,39.47 13.81,39.47 14.09,39.19 14.45,39.19 14.88,38.77 CHOKE16.2
USB3_TX_P2: length 77
  TOP w0.102: v1(38.46,70.49) 38.84,70.1 38.96,70.1 40.13,71.28 40.13,75.01 43.97,78.84 48.72,78.84 54.89,72.67 54.89,68.63 55.17,68.35 55.17,66.93 55.97,66.12 PCH1.A12 ; v1(28.45,68.2) 28.04,67.79 26.49,67.79 21.03,62.33 21.03,41.56 20.92,41.45 20.72,41.45 C561.1
  BOTTOM w0.102: v1(38.46,70.49) 38.46,70.28 38.2,70.03 37.44,70.03 36.88,70.59 31.8,70.59 29.08,67.87 28.78,67.87 v1(28.45,68.2)
USB3_TX_P2_C: length 2.7
  TOP w0.102: C561.2 18.82,41.41 18.48,41.41 18.11,41.05 17.91,41.05 17.56,41.4 CHOKE15.4
USB3_TX_P2_R: length 16.2
  TOP w0.102: USB3F1.14 6.21,38.56 5.99,38.79 5.61,38.79 5.18,39.22 5.18,40.7 5.66,41.17 6.88,41.17 7.14,41.44 7.14,42.48 7.87,43.21 9.28,43.21 11.3,41.19 11.5,41.19 11.65,41.34 D19.1 D19.10 13.45,41.34 13.64,41.15 14.45,41.15 14.7,41.4 CHOKE15.3
USB3_TX_P3: length 195.9
  TOP w0.102: PCH1.D13 56.51,63.23 56.29,63.46 56.29,63.82 56.2,63.9 56.2,66.34 55.51,67.04 55.51,68.53 55.37,68.67 55.37,72.9 48.92,79.35 43.66,79.35 37.21,85.8 37.21,89.33 37.72,89.84 38.05,89.84 v1(38.4,90.2) ; v1(96.75,214.84) 96.44,215.14 96.44,215.78 C89.1
  BOTTOM w0.102: v1(38.4,90.2) 38.76,89.84 38.91,89.84 39.07,89.99 39.07,109 45.31,115.25 45.31,120.07 46.66,121.42 46.66,168.54 64.56,186.44 65.85,186.44 77.47,198.05 77.47,202.29 91.67,216.5 95.35,216.5 96.49,215.35 96.49,215.09 v1(96.75,214.84)
USB3_TX_P3_C: length 4.5
  TOP w0.102: CHOKE9.4 98.77,219.04 98.37,218.64 98.37,218.54 97.77,217.93 96.57,217.93 96.16,217.53 96.16,217.32 C89.2
USB3_TX_P3_R: length 13.4
  TOP w0.102: USB3X2.18 105.3,228.64 105.03,228.37 105.03,227.55 104.13,226.64 99.64,226.64 98.77,225.77 98.77,224.46 98.92,224.32 U13.9 U13.2 98.92,222.61 98.7,222.4 98.7,222.27 98.5,222.06 98.5,221.97 98.77,221.7 CHOKE9.3
USB3_TX_P4: length 195.6
  TOP w0.102: v1(98.68,214.73) 98.35,215.06 98.35,215.5 C91.1 ; PCH1.B13 56.74,64.26 56.74,66.52 56.06,67.21 56.06,73.23 49.25,80.04 49.2,80.04 48.8,80.04 48.8,80.04 44.14,80.04 40.67,83.51 40.67,84.96 39.95,85.67 39.26,85.67 v1(39.01,85.42)
  BOTTOM w0.102: v1(39.01,85.42) 39.26,85.67 39.62,85.67 39.98,86.03 39.98,108.65 46.2,114.88 46.2,119.58 47.55,120.93 47.55,168.17 64.93,185.55 66.23,185.55 78.36,197.68 78.36,201.9 92.05,215.6 93.75,215.6 96.01,213.33 97.77,213.33 98.3,213.86 98.3,214.35 v1(98.68,214.73)
