# Allegro board ECS H11H4-AD2 v1.1 boardview.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
USB3_TX_P4_C: length 4.3
  TOP w0.102: C91.2 98.32,217.34 98.32,217.47 98.48,217.63 99.63,217.63 100.18,218.18 100.18,218.59 100.55,218.97 CHOKE10.4
USB3_TX_P4_R: length 17
  TOP w0.102: USB3X2.9 105.09,231.84 104.93,231.68 104.93,231.32 105.14,231.11 105.54,231.11 106.65,230 106.65,227.97 104.42,225.73 100.99,225.73 100.28,225.02 100.28,224.41 100.42,224.27 U13.6 U13.5 100.42,222.63 100.28,222.49 100.28,222.07 100.55,221.8 CHOKE10.3
USB10+: length 3
  TOP w0.102: L21.4 46.2,110.95 45.77,111.38 45.77,112.17 45.94,112.33 M2_1.3
USB10-: length 2.9
  TOP w0.102: L21.1 45.19,110.95 45.57,111.33 45.57,112.17 45.44,112.3 M2_1.5
USB+5: length 36.9
  TOP w0.102: L8.4 56.75,212.54 57.07,212.22 57.56,212.22 60.13,209.65 61.57,209.65 62.05,210.13 62.05,210.39 62.72,211.06 62.72,211.91 U16.6 62.72,212.31 62.72,212.83 62.11,213.44 62.11,215.71 62.83,216.43 64.36,216.43 69.88,221.95 69.88,225.13 70.86,226.11 74.9,226.11 76.56,227.76 76.56,228.78 76.11,229.22 USB2_LAN.U7
USB+6: length 37.8
  TOP w0.102: USB2_LAN.U3 76.43,231.15 76.43,230.74 76.24,230.56 75.21,230.56 74.35,229.69 74.35,228.07 73.17,226.9 70.63,226.9 69.19,225.46 69.19,222.39 64.1,217.3 61.75,217.3 60.21,215.76 60.21,213.47 60.82,212.86 60.82,212.31 U16.4 60.82,211.91 60.82,211.4 60.52,211.1 59.82,211.1 57.91,213 57.91,213.39 57.06,214.25 56.85,214.25 56.55,214.55 L7.4
USB+7: length 11.4
  TOP w0.102: F_USB1.6 7.21,21.03 7.49,21.31 7.8,21.31 8.21,20.9 8.21,19.19 9.2,18.2 10.81,18.2 11.41,18.81 12.32,18.81 U42.6 12.73,18.81 13.27,18.81 13.59,18.49 13.87,18.49 14.24,18.12 L25.4
USB+8: length 15.2
  TOP w0.102: L26.4 14.17,16.34 13.84,16.66 13.54,16.66 13.29,16.91 12.73,16.91 U42.4 12.32,16.91 11.7,16.91 11.09,16.3 9.04,16.3 8.2,17.14 8.2,18.26 7.57,18.9 6.43,18.9 5.87,19.46 5.87,20.9 5.41,21.36 5.08,21.36 4.67,20.96 F_USB1.5
USB+9: length 12
  TOP w0.102: F_USB2.3 4.93,71.86 5.23,72.16 6.35,72.16 6.81,71.7 6.81,70.74 7.15,70.39 9.04,70.39 9.64,71 10.39,71 U32.6 10.8,71 11.65,71 12.29,70.36 12.75,70.36 13.25,69.85 CMK1.1
USB-5: length 37.3
  TOP w0.102: USB2_LAN.U6 77.25,229.22 76.76,228.73 76.76,227.68 74.99,225.91 70.94,225.91 70.08,225.04 70.08,221.87 64.44,216.23 62.92,216.23 62.32,215.63 62.32,214.81 U16.1 62.32,214.41 62.32,213.52 62.93,212.91 62.93,210.97 62.26,210.3 62.26,210.05 61.65,209.45 60.05,209.45 57.48,212.01 57.12,212.01 56.8,211.69 L8.1
USB-6: length 38.7
  TOP w0.102: L7.1 56.5,213.7 56.85,214.05 56.97,214.05 57.71,213.31 57.71,212.92 59.73,210.9 60.6,210.9 61.03,211.32 61.03,212.95 60.42,213.56 60.42,214.41 U16.3 60.42,214.81 60.42,215.68 61.83,217.09 64.19,217.09 69.39,222.3 69.39,225.37 70.71,226.69 73.25,226.69 74.55,227.99 74.55,229.61 75.29,230.35 76.33,230.35 76.63,230.66 76.63,231.42 77.05,231.84 USB2_LAN.U2
USB-7: length 11.5
  TOP w0.102: L25.1 14.22,18.97 13.94,18.69 13.67,18.69 13.36,19.01 11.33,19.01 10.72,18.4 10.23,18.4 U42.1 9.82,18.4 9.29,18.4 8.41,19.27 8.41,20.99 7.89,21.51 7.39,21.51 7.21,21.69 F_USB1.4
USB-8: length 15.2
  TOP w0.102: F_USB1.3 4.67,22.05 5.16,21.56 5.49,21.56 6.07,20.99 6.07,19.54 6.51,19.1 7.65,19.1 8.41,18.35 8.41,17.22 9.13,16.5 9.82,16.5 U42.3 10.23,16.5 11.01,16.5 11.61,17.11 13.38,17.11 13.62,16.87 13.82,16.87 14.17,17.22 14.64,17.22 L26.1
USB-9: length 11.9
  TOP w0.102: CMK1.4 13.1,70.86 12.8,70.56 12.38,70.56 11.73,71.21 9.56,71.21 8.95,70.6 8.3,70.6 U32.1 7.89,70.6 7.24,70.6 7.01,70.82 7.01,71.79 6.43,72.36 5.21,72.36 4.93,72.64 F_USB2.2
USB_EN: length 238.7
  TOP w0.102: R213.1 72.9,199.57 v1(72.9,199.19) 74.2,197.89 77.27,197.89 87.27,207.9 94.67,207.9 99.82,213.06 99.82,216.59 101.21,217.97 101.21,218.33 101.52,218.64 102.31,218.64 102.9,218.06 102.9,217.52 R153.1 ; RJ4.2 12.58,57.75 R460.2 R481.2 v1(14.96,58.64) 14.93,58.67 R437.1 ; v1(53.24,178.79) 53.24,178 51.54,176.3 41.12,176.3 40.46,175.64 36.88,175.64 34.92,177.6 31.55,177.6 29.49,179.65 29.49,179.86 29.13,180.21 28.65,180.21 28.04,180.82 v1(27.97,180.82)
  BOTTOM w0.102: v1(53.24,178.79) 53.77,179.32 55.04,179.32 63.83,188.11 65.18,188.11 72.9,195.84 v2(72.9,198) v1(72.9,199.19) ; v1(27.97,180.82) 26.57,179.43 26.57,140.28 27.29,139.57 27.28,139.56 27.28,128.19 22.99,123.9 22.99,114.07 10.95,102.03 10.95,80.82 13.79,77.98 13.79,74.88 14.76,73.91 14.76,67.89 15.47,67.18 15.47,59.15 v1(14.96,58.64)
USB_EN1: length 79.9
  TOP w0.102: v1(15.32,21.74) 15.49,21.56 20.7,21.56 21.27,22.13 U40.4 ; v1(13.23,59.89) 13.69,59.44 R437.2 C489.1 14.07,60.67 14.07,62.74 13.56,63.25 U33.2 ; v1(11.23,72.34) 16.48,72.34 16.82,72.68 U30.4
  BOTTOM w0.102: 9.8,59.84 9.63,59.66 9.63,54.66 11.68,52.6 11.68,28.12 12.55,27.25 12.55,23.47 14.27,21.74 v1(15.32,21.74) ; 9.8,59.84 9.86,59.89 v1(13.23,59.89) ; 9.8,59.84 8.25,61.39 8.25,64.87 9.88,66.5 9.88,70.99 v2(10.52,71.63) v1(11.23,72.34)
USB_EN2: length 4.5
  TOP w0.102: U15.2 102.13,214.05 101.88,214.3 101.88,216.41 C126.1 102.82,216.49 R153.2
USB_EN3: length 3
  TOP w0.102: R213.2 v1(74.32,200.03) C186.1 75.06,201.28 U20.4
USB_H1: length 27.4
  TOP w0.102: USB3X2.12 100.95,229.84 101.42,229.84 101.6,230.02 101.6,230.56 100.56,231.6 100.56,232.07 99.44,233.19 99.44,234.05 98.87,234.62 97.95,234.62 96.12,232.79 93.78,232.79 92.79,231.8 92.79,226.31 92.24,225.76 92.24,223.1 91.63,222.49 91.63,221.91 U14.3 91.63,221.51 91.63,220.4 92.07,219.96 RN7.8
USB_H2: length 31.8
  TOP w0.102: CHOKE13.3 90.39,219.92 90.04,220.27 90.04,220.58 89.73,220.9 89.73,221.51 U14.1 89.73,221.91 89.73,222.51 90.34,223.12 90.34,226.3 91.67,227.63 91.67,235.74 93.78,237.85 98.2,237.85 101.7,234.34 101.7,233.58 101.46,233.34 USB3X2.3
USB_L1: length 27.4
  TOP w0.102: USB3X2.11 101.99,230.14 101.8,230.33 101.8,230.64 100.76,231.68 100.76,232.16 99.64,233.27 99.64,234.14 98.96,234.82 97.87,234.82 96.04,232.99 93.69,232.99 92.58,231.88 92.58,226.39 92.03,225.84 92.03,224.41 U14.4 92.03,224.01 92.03,223.18 91.42,222.57 91.42,220.33 91.26,220.17 RN7.6
USB_L2: length 31.8
  TOP w0.102: CHOKE13.2 89.54,219.95 89.84,220.24 89.84,220.5 89.52,220.81 89.52,222.6 90.13,223.21 90.13,224.01 U14.6 90.13,224.41 90.13,226.39 91.47,227.72 91.47,235.82 93.69,238.05 98.28,238.05 101.9,234.42 101.9,234.09 USB3X2.2
USB_N1: length 270.5
  TOP w0.089: v3(52.39,51.47) 52.68,51.76 PCH1.AF5
  TOP w0.102: v1(87.07,217.27) 87.43,216.92 87.54,216.92 87.91,216.54 87.91,215.6 88.49,215.01 90.14,215.01 91.62,216.48 91.62,216.69 91.26,217.04 RN7.5
  BOTTOM w0.102: v1(87.07,217.27) 86.72,216.92 86.46,216.92 84.48,214.93 77,214.93 75.81,213.74 46.43,213.74 39.8,207.11 39.8,204.27 38.86,203.33 33.68,203.33 31.17,200.81 31.17,186.94 30,185.77 30,183.69 31.24,182.45 31.24,179.18 28.91,176.84 28.91,141.4 36.65,133.65 36.65,118.39 27.2,108.94 27.2,89.74 20.35,82.88 20.35,70.14 21.11,69.38 21.11,52.93 26.39,47.65 31.72,47.65 33.32,46.05 38.2,46.05 42.27,50.11 44.65,50.11 45.44,50.9 50.29,50.9 51.28,51.89 52.53,51.89 52.63,51.79 52.63,51.7 v3(52.39,51.47)
USB_N2: length 265.6
  TOP w0.089: v3(52.99,52.53) 52.63,52.89 PCH1.AD5
  TOP w0.102: RN7.1 89.64,217.12 89.89,216.87 89.89,216.66 89.74,216.51 89.53,216.51 89.18,216.87 89.03,216.87 v1(88.68,217.21)
  BOTTOM w0.102: v3(52.99,52.53) 53.27,52.81 53.27,52.9 53.16,53.01 51.39,53.01 50.32,51.94 48.67,51.94 48.26,52.35 45.87,52.35 44.37,50.84 42,50.84 37.9,46.74 33.7,46.74 32.1,48.34 26.7,48.34 21.79,53.24 21.79,69.66 21.06,70.4 21.06,82.61 27.89,89.44 27.89,108.64 37.34,118.08 37.34,134.47 29.64,142.16 29.64,176.59 31.93,178.87 31.93,200.36 34.08,202.51 39.47,202.51 40.55,203.59 40.55,206.8 46.58,212.83 76.05,212.83 77.22,214 86.39,214 87.81,215.42 87.81,216.54 88.16,216.89 88.37,216.89 v1(88.68,217.21)
USB_N3: length 48.5
  TOP w0.089: v3(53.85,51.49) 54.16,51.8 PCH1.AG8
  TOP w0.102: v1(25.87,38.58) 25.87,38.34 25.73,38.2 24.58,38.2 20.04,33.66 20.04,31.72 19.18,30.86 18.95,30.86 18.65,31.16 CMK3.1
  BOTTOM w0.102: v1(25.87,38.58) 25.87,38.29 26.03,38.13 26.52,38.13 32.56,44.17 34.76,44.17 35.48,44.88 38.73,44.88 42.74,48.9 45.67,48.9 46.56,49.78 54.14,49.78 54.41,50.05 54.41,50.52 54.1,50.83 54.1,51.24 v3(53.85,51.49)
USB_N3_R: length 14.5
  TOP w0.102: RN11.4 15.9,31.17 15.67,30.94 15.52,30.94 15.15,30.57 15.15,30.25 15.09,30.19 14.51,30.19 U39.4 14.1,30.19 13.23,30.19 12.62,30.8 10.09,30.8 9.44,30.15 8.08,30.15 7.24,30.99 7.24,32.85 6.89,33.2 6.43,33.2 6.21,33.41 USB3F1.12
USB_N4: length 62.6
  TOP w0.102: v1(28.42,60.6) 28.58,60.6 28.73,60.45 28.73,59.31 27.38,57.96 27.38,54.71 23.95,51.28 23.95,38.66 19.33,34.04 19.33,32.62 19.19,32.49 19.05,32.49 18.68,32.86 CMK2.1 ; PCH1.AE1 49.82,52.67 48.77,53.72 47.63,53.72 46.69,54.66 43.92,54.66 42.54,56.03 42.54,57.57 41.95,58.17 40.39,58.17 v2(40.06,57.84) 39.73,58.17 37.74,58.17 37.36,58.55 37.36,59.74 37.08,60.02 36.8,60.02 36.57,59.78 v1(36.57,59.57)
  BOTTOM w0.102: v1(28.42,60.6) 28.58,60.6 28.73,60.45 28.73,59.76 29.2,59.28 35.41,59.28 36.12,59.99 36.37,59.99 36.57,59.8 v1(36.57,59.57)
USB_N4_R: length 12
  TOP w0.102: USB3F1.8 8.21,35.34 8.43,35.12 9.59,35.12 10.06,34.65 10.06,32.78 10.74,32.09 11.6,32.09 U39.1 12.01,32.09 12.78,32.09 13.39,32.7 15.18,32.7 15.44,32.44 15.6,32.44 15.95,32.79 RN11.8
USB_N5: length 218.9
  TOP w0.102: L8.2 53.92,211.69 53.52,212.09 52.2,212.09 50.67,210.56 50.67,210.46 v1(50.92,210.22) ; v1(43.43,56.41) 43.66,56.41 43.87,56.21 43.87,55.73 44.25,55.35 47.06,55.35 48.07,54.33 49.57,54.33 49.93,53.97 50.87,53.97 50.94,53.9 51.28,53.9 51.33,53.85 PCH1.AC2
  BOTTOM w0.102: v1(43.43,56.41) 43.66,56.41 43.87,56.21 43.87,55.93 43.18,55.25 41.12,55.25 37.33,51.46 34.8,51.46 34.26,51.99 26.87,51.99 24.26,54.61 24.26,70.68 23.93,71.01 23.93,84.2 28.78,89.05 28.78,108.25 38.23,117.7 38.23,135.92 30.53,143.62 30.53,176.2 32.82,178.49 32.82,199.9 34.39,201.47 39.78,201.47 41.55,203.24 41.55,206.45 46.76,211.66 48,211.66 49.6,210.06 50.24,210.06 50.57,210.39 50.75,210.39 v1(50.92,210.22)
USB_N6: length 217.1
  TOP w0.102: L7.2 54,213.7 53.77,213.93 53.75,213.92 51.26,213.92 50.8,213.46 v2(50.8,212.98) 50.32,212.98 48.03,210.69 48.03,210.31 v1(48.15,210.2) ; PCH1.AF2 51.03,52.2 49.4,52.2 48.59,53.01 47.29,53.01 46.32,53.97 43.63,53.97 41.51,56.1 41.51,56.6 41.23,56.88 v1(41.12,56.88)
  BOTTOM w0.102: v1(48.15,210.2) 48.03,210.31 47.76,210.31 47.3,209.85 45.96,209.85 42.39,206.29 42.39,202.64 40.39,200.63 34.65,200.63 33.5,199.48 33.5,178.18 31.22,175.9 31.22,144.23 38.91,136.53 38.91,117.39 29.46,107.94 29.46,88.75 24.61,83.9 24.61,71.3 24.94,70.97 24.94,54.95 27.16,52.73 34.54,52.73 35.13,52.15 37.03,52.15 40.84,55.96 41.22,55.96 41.43,56.17 41.43,56.57 v1(41.12,56.88)
USB_N7: length 77
  TOP w0.089: PCH1.AB3 51.55,54.33 51.28,54.6 50.42,54.6 49.84,55.18 49.39,55.18 49.17,55.4 v3(49.17,55.68)
  TOP w0.102: v1(28.22,26.67) 27.86,26.31 27.63,26.31 25.5,24.19 25.5,22.56 20.9,17.96 18.09,17.96 17.41,18.64 17.3,18.64 16.97,18.97 L25.2
  BOTTOM w0.089: 55.67,53.81 55.66,53.83 55.65,53.83 55.61,53.87 54.22,53.87 53.66,54.43 50.01,54.43 49.17,55.27 v3(49.17,55.68)
  BOTTOM w0.102: 55.67,53.81 56.31,53.17 56.31,50.56 55.33,49.59 55.33,48.82 54.72,48.21 54.5,48.21 53.12,46.84 52.63,46.84 52.53,46.74 47.89,46.74 46.74,45.59 41.79,45.59 39.51,43.31 36.17,43.31 35.28,42.42 33.12,42.42 29.41,38.71 29.41,34.39 28.22,33.2 28.22,28.16 27.66,27.6 27.66,26.42 27.76,26.31 27.86,26.31 v1(28.22,26.67)
USB_N8: length 62.9
  TOP w0.089: v3(54.64,49.17) 54.26,49.55 PCH1.AL8
  TOP w0.102: L26.2 16.9,17.19 17.22,16.87 20.82,16.87 26.19,22.23 26.19,23.68 27.09,24.59 27.24,24.59 v1(27.62,24.97)
  BOTTOM w0.089: 54.43,49.17 54.02,48.76 54.02,48.44 53,47.42 51.36,47.42 50.98,47.8 50.92,47.8
  BOTTOM w0.102: 50.92,47.8 48.04,47.8 46.57,46.33 41.46,46.33 39.12,43.99 35.86,43.99 35.15,43.28 32.97,43.28 27.91,38.23 27.91,35.51 v2(28.24,35.18) 27.91,34.85 27.91,34.08 27.48,33.65 27.48,28.59 26.92,28.03 26.92,24.79 27.13,24.59 27.24,24.59 v1(27.62,24.97) ; 54.43,49.17 v3(54.64,49.17)
USB_N9: length 70.8
  TOP w0.102: v3(45.24,56.94) 45.55,56.64 45.55,56.3 45.74,56.11 49.5,56.11 50.66,54.95 PCH1.AA1 ; CMK1.3 15.73,70.86 16.26,70.33 16.4,70.33 19.49,73.42 19.49,76.57 20.88,77.95 22.05,77.95 22.28,78.19 v1(22.28,78.51)
  BOTTOM w0.102: v1(22.28,78.51) 22.28,78.25 22.5,78.03 22.91,78.03 23.2,77.74 23.2,70.77 23.57,70.4 23.57,54.28 26.54,51.31 33.96,51.31 34.49,50.77 37.62,50.77 41.4,54.56 43.89,54.56 45.58,56.25 45.58,56.6 v3(45.24,56.94)
USB_N10: length 122.2
  TOP w0.089: PCH1.AJ8 54.26,50.58 v3(53.95,50.27)
  TOP w0.102: v1(24.08,103.33) 24.08,103.23 24.42,102.9 24.66,102.9 25.09,103.33 44.21,103.33 45.59,104.71 45.59,106.71 v2(45.26,107.04) 45.59,107.37 45.59,108.05 45.19,108.45 L21.2
  BOTTOM w0.102: v3(53.95,50.27) 53.75,50.48 53.75,50.75 53.54,50.95 51.18,50.95 50.7,50.47 45.79,50.47 44.9,49.58 42.44,49.58 38.42,45.57 35.04,45.57 34.49,45.01 33.53,45.01 31.37,47.17 26.19,47.17 20.62,52.73 20.62,69.18 19.84,69.96 19.84,83.13 26.59,89.88 26.59,96.47 25.12,97.94 25.12,102.65 24.77,103 24.41,103 v1(24.08,103.33)
USB_OC2_L: length 12.7
  TOP w0.089: v3(69.39,52.53) PCH1.AD39 ; v3(76.33,52.37) 77.9,52.37 79.22,51.05
  TOP w0.102: 79.22,51.05 79.6,50.67 R511.1
  BOTTOM w0.089: v3(76.33,52.37) 76.12,52.17 73.18,52.17 v2(72.75,52.6) 72.33,53.02 69.88,53.02 v3(69.39,52.53)
USB_OC3_L: length 9.7
  TOP w0.089: 75.98,53.65 75.06,53.65 74.9,53.49 72.24,53.49 72.1,53.63 PCH1.AC44
  TOP w0.102: 75.98,53.65 79.96,53.65 R494.1 R502.1
USB_OC7_L: length 15.7
  TOP w0.089: 79.22,60.83 75.59,57.2 74.79,57.2 73.82,56.24 72.24,56.24 72.13,56.13 71.66,56.13 71.42,55.9 PCH1.W43
  TOP w0.102: 79.22,60.83 79.58,61.19 82.25,61.19 83.03,61.98 R444.1
USB_P1: length 270.4
  TOP w0.089: PCH1.AG7 53.05,51.61 v3(53.05,51.44)
  TOP w0.102: RN7.7 92.07,216.94 91.82,216.69 91.82,216.4 90.23,214.81 88.41,214.81 87.71,215.51 87.71,216.46 87.45,216.71 87.33,216.71 v1(87.07,216.46)
  BOTTOM w0.102: v1(87.07,216.46) 86.82,216.71 86.55,216.71 84.56,214.73 77.09,214.73 75.9,213.54 46.52,213.54 40,207.03 40,204.18 38.95,203.12 33.76,203.12 31.37,200.73 31.37,186.86 30.2,185.69 30.2,183.78 31.45,182.53 31.45,179.1 29.11,176.76 29.11,141.49 36.86,133.74 36.86,118.31 27.41,108.86 27.41,89.65 20.55,82.8 20.55,70.22 21.31,69.46 21.31,53.02 26.47,47.85 31.8,47.85 33.4,46.25 38.12,46.25 42.18,50.32 44.57,50.32 45.36,51.1 50.21,51.1 51.2,52.1 52.61,52.1 52.83,51.87 52.83,51.66 v3(53.05,51.44)
USB_P2: length 265.6
  TOP w0.089: v3(53.75,52.53) 53.39,52.89 PCH1.AD7
  TOP w0.102: RN7.3 90.45,217.2 90.09,216.84 90.09,216.58 89.82,216.31 89.45,216.31 89.1,216.66 88.95,216.66 v1(88.67,216.38)
  BOTTOM w0.102: v3(53.75,52.53) 53.47,52.81 53.47,52.99 53.25,53.21 51.3,53.21 50.24,52.15 48.75,52.15 48.34,52.55 45.79,52.55 44.28,51.05 41.92,51.05 37.81,46.94 33.78,46.94 32.18,48.54 26.78,48.54 22,53.32 22,69.74 21.26,70.48 21.26,82.52 28.09,89.36 28.09,108.55 37.54,118 37.54,134.55 29.84,142.25 29.84,176.5 32.13,178.79 32.13,200.28 34.16,202.31 39.56,202.31 40.75,203.51 40.75,206.72 46.66,212.62 76.13,212.62 77.3,213.79 86.47,213.79 88.01,215.33 88.01,216.46 88.24,216.69 88.37,216.69 88.67,216.38 v1(88.67,216.38)
USB_P3: length 48.4
  TOP w0.089: v3(54.49,51.44) 54.92,51.87 PCH1.AG10
  TOP w0.102: v1(25.87,37.67) 25.54,38 24.66,38 20.24,33.58 20.24,31.64 19.26,30.66 19,30.66 18.65,30.31 CMK3.4
  BOTTOM w0.102: v1(25.87,37.67) 26.12,37.92 26.6,37.92 32.65,43.97 34.85,43.97 35.56,44.68 38.81,44.68 42.82,48.69 45.75,48.69 46.64,49.58 54.23,49.58 54.61,49.96 54.61,50.6 54.31,50.91 54.31,51.26 v3(54.49,51.44)
USB_P3_R: length 14.6
  TOP w0.102: RN11.2 15.98,30.35 15.67,30.66 15.53,30.66 15.35,30.48 15.35,30.17 15.17,29.99 13.14,29.99 12.53,30.6 12.01,30.6 U39.3 11.6,30.6 10.18,30.6 9.52,29.95 7.99,29.95 7.04,30.9 7.04,32.77 6.81,32.99 6.53,32.99 6.21,32.68 USB3F1.11
USB_P4: length 62.7
  TOP w0.102: v1(29.21,60.62) 28.93,60.34 28.93,59.22 27.58,57.88 27.58,54.63 24.16,51.2 24.16,38.57 19.53,33.95 19.53,32.54 19.28,32.28 19.02,32.28 18.75,32.01 CMK2.4 ; PCH1.AE2 51.03,52.91 50.62,52.91 50.58,52.88 49.9,52.88 48.85,53.92 47.71,53.92 46.77,54.86 44,54.86 42.75,56.12 42.75,57.66 42.04,58.37 38.68,58.37 v2(38.35,58.7) 38.02,58.37 37.83,58.37 37.57,58.63 37.57,59.83 37.17,60.22 36.83,60.22 v1(36.57,60.49)
  BOTTOM w0.102: v1(29.21,60.62) 28.93,60.34 28.93,59.84 29.29,59.49 35.32,59.49 36.03,60.2 36.28,60.2 v1(36.57,60.49)
USB_P4_R: length 12
  TOP w0.102: RN11.6 15.9,31.98 15.65,32.23 15.36,32.23 15.09,32.5 14.51,32.5 U39.6 14.1,32.5 13.47,32.5 12.86,31.89 10.66,31.89 9.86,32.69 9.86,34.57 9.51,34.92 8.39,34.92 8.21,34.75 USB3F1.9
USB_P5: length 219.3
  TOP w0.102: L8.3 53.82,212.54 53.57,212.29 52.12,212.29 50.69,210.87 v1(50.27,210.87) ; PCH1.AC3 51.71,53.82 51.42,54.1 51.03,54.1 50.95,54.18 50.01,54.18 49.66,54.53 48.16,54.53 47.14,55.55 44.33,55.55 44.07,55.81 44.07,56.21 v1(44.3,56.44)
  BOTTOM w0.102: v1(44.3,56.44) 44.07,56.21 44.07,55.85 43.26,55.04 41.2,55.04 37.42,51.26 34.71,51.26 34.18,51.79 26.79,51.79 24.05,54.53 24.05,70.6 23.72,70.93 23.72,84.29 28.57,89.14 28.57,108.33 38.02,117.78 38.02,135.84 30.33,143.54 30.33,176.28 32.61,178.57 32.61,199.98 34.31,201.68 39.7,201.68 41.35,203.33 41.35,206.54 46.68,211.86 48.08,211.86 49.68,210.26 50.16,210.26 50.27,210.37 v1(50.27,210.87)
USB_P6: length 218
  TOP w0.102: L7.3 54.1,214.55 53.67,214.12 51.17,214.12 49.57,212.52 v2(49.1,212.52) 49.1,212.05 47.89,210.84 v1(47.5,210.84) ; v1(41.91,56.88) 41.71,56.68 41.71,56.18 43.71,54.18 46.41,54.18 47.37,53.21 48.68,53.21 49.49,52.4 51.2,52.4 51.55,52.06 PCH1.AF3
  BOTTOM w0.102: v1(41.91,56.88) 41.63,56.6 41.63,56.08 41.3,55.75 40.92,55.75 37.11,51.94 35.04,51.94 34.46,52.53 27.08,52.53 24.74,54.86 24.74,70.88 24.41,71.21 24.41,83.98 29.26,88.83 29.26,108.03 38.71,117.48 38.71,136.45 31.01,144.15 31.01,175.98 33.3,178.27 33.3,199.57 34.57,200.84 40.3,200.84 42.19,202.73 42.19,206.38 45.87,210.06 47.22,210.06 47.5,210.34 v1(47.5,210.84)
USB_P7: length 77
  TOP w0.089: v3(48.6,55.11) 48.79,55.3 49,55.3 49.31,54.99 49.76,54.99 50.34,54.41 51.1,54.41 PCH1.AB2
  TOP w0.102: L25.3 16.95,18.12 17.27,18.44 17.32,18.44 18.01,17.75 20.98,17.75 25.7,22.48 25.7,24.1 27.71,26.11 27.86,26.11 v1(28.22,25.76)
  BOTTOM w0.089: v3(48.6,55.11) 48.68,55.19 48.98,55.19 49.93,54.24 53.58,54.24 54.15,53.68 55.52,53.68 55.52,53.67
  BOTTOM w0.102: v1(28.22,25.76) 27.86,26.11 27.68,26.11 27.46,26.33 27.46,27.69 28.02,28.24 28.02,33.28 29.21,34.48 29.21,38.79 33.04,42.62 35.2,42.62 36.09,43.51 39.42,43.51 41.71,45.8 46.66,45.8 47.8,46.94 52.44,46.94 52.54,47.04 53.04,47.04 54.41,48.42 54.64,48.42 55.13,48.91 55.13,49.67 56.11,50.65 56.11,53.09 55.52,53.67
USB_P8: length 62.8
  TOP w0.089: v3(53.83,49.17) 53.5,49.5 PCH1.AL7
  TOP w0.102: L26.3 16.92,16.34 17.25,16.66 20.9,16.66 26.39,22.15 26.39,23.6 27.18,24.38 27.29,24.38 v1(27.62,24.05)
  BOTTOM w0.089: 50.92,48.01 50.93,48.01 50.94,48 51,48 51.01,47.99 51.06,47.99 51.44,47.61 52.92,47.61 53.83,48.52 v3(53.83,49.17)
  BOTTOM w0.102: 50.92,48.01 47.96,48.01 46.48,46.53 41.38,46.53 39.04,44.2 35.78,44.2 35.07,43.48 32.88,43.48 27.71,38.31 27.71,37.54 v2(27.38,37.21) 27.71,36.88 27.71,34.16 27.28,33.73 27.28,28.68 26.72,28.12 26.72,24.71 27.04,24.38 27.29,24.38 v1(27.62,24.05)
USB_P9: length 70.8
  TOP w0.102: PCH1.AA2 51.13,54.95 50.9,55.17 50.72,55.17 49.58,56.31 45.83,56.31 45.75,56.39 45.75,56.64 v3(46.05,56.94) ; v1(22.28,77.5) 22.03,77.75 20.96,77.75 19.7,76.48 19.7,73.34 16.49,70.13 16.15,70.13 15.88,69.85 CMK1.2
  BOTTOM w0.102: v3(46.05,56.94) 45.79,56.67 45.79,56.17 43.98,54.36 41.49,54.36 37.7,50.57 34.41,50.57 33.88,51.1 26.46,51.1 23.37,54.2 23.37,70.31 23,70.69 23,77.66 22.83,77.83 22.61,77.83 v1(22.28,77.5)
USB_P10: length 122.1
  TOP w0.102: L21.3 46.2,108.45 45.8,108.05 45.8,105.69 46.15,105.33 ; 46.15,105.33 v2(46.13,105.33) ; 46.15,105.33 45.8,104.98 45.8,104.62 44.3,103.12 25.17,103.12 24.74,102.69 24.34,102.69 v1(24.09,102.44) ; v3(53.29,50.26) 53.5,50.47 PCH1.AJ7
  BOTTOM w0.102: v1(24.09,102.44) 24.44,102.79 24.69,102.79 24.92,102.57 24.92,97.86 26.39,96.38 26.39,89.97 19.63,83.21 19.63,69.88 20.42,69.09 20.42,52.65 26.1,46.96 31.28,46.96 33.44,44.81 34.57,44.81 35.13,45.36 38.51,45.36 42.52,49.38 44.98,49.38 45.87,50.27 50.78,50.27 51.27,50.75 53.46,50.75 53.54,50.66 53.54,50.51 v3(53.29,50.26)
VBOOT_V1P05: length 11.8
  TOP w0.203: U19.45 164.67,206.48 163.17,204.98 C170.2 163.17,204.44
  TOP w0.254: 163.17,204.44 162.98,204.44 161.99,203.45 R185.2 161.49,203.84 159.96,203.84 C175.2 158.95,203.84 157.99,203.84 R184.1
VBOOT_V1P05_Q: length 2.4
  TOP w0.254: Q11.3 156.94,200.4 157.33,200.79 R184.2
VCORE_GSENS: length 119.5
  TOP w0.203: v1(167.89,221.77) 167.51,221.77 C49.1 167.31,221.27 167.31,219.5 R93.2 167.23,219.23 167.74,218.72 167.74,217.93 166.98,217.17 166.78,217.17 C85.2 165.07,215.46 U19.20 ; v5(140.02,162.66) CPU1.D38
  BOTTOM w0.203: v1(167.89,221.77) 168.07,221.95 169.12,221.95 169.67,222.5 169.67,222.78 170.79,223.9 173.95,223.9 176.62,221.23 178.22,221.23 180.83,218.62 181.95,217.5 182.66,217.5 185.27,214.89 185.27,208.86 183.78,207.37 178.37,207.37 177.1,206.1 174.89,206.1 173.03,204.24 170.54,204.24 169.57,203.28 167.97,203.28 165.9,201.2 165.53,201.2 164.77,200.44 164.04,199.72 164.04,190.37 164.95,189.46 164.95,183.13 160.25,178.44 154.09,178.44 152.45,176.8 152.45,174.99 152.18,174.72 SR14.1 152.18,173.87 152.45,173.6 152.45,172.92 v2(152.2,172.67) 152.45,172.42 152.45,171.53 151.49,170.56 147.07,170.56 144.12,167.61 144.12,164.67 143.26,163.8 140.67,163.8 140.26,163.4 140.26,162.9 v5(140.02,162.66)
VCORE_GT_GSENS: length 68
  TOP w0.203: CPU1.F38 140.48,160.35 v5(140.03,159.91) ; v1(166.31,198.84) 165.99,199.16 165.99,199.7 C189.1 166.19,200.47 R202.2 164.77,201.89 164.77,204.01 C171.2 165.87,205.11 U19.48
  BOTTOM w0.089: 144.44,163.31 144.42,163.29 144.42,163.2 142.42,161.2 140.73,161.2 140.39,160.86 140.39,160.26 v5(140.03,159.91)
  BOTTOM w0.203: 144.44,163.31 145.44,164.31 145.44,167.25 147.61,169.42 152.81,169.42 166.07,182.67 166.07,191.09 165.63,191.53 165.63,196.77 166.88,198.02 166.88,199.4 166.65,199.62 166.27,199.62 166.07,199.42 166.07,199.08 v1(166.31,198.84)
VCORE_GT_SENS: length 66
  TOP w0.203: R214.1 C184.1 162.15,201.2 R201.1 164.21,201.2 C181.1 164.24,200.46 164.09,200.31 C188.2 C189.2 165.58,199.55 165.58,199.06 v1(165.38,198.86) ; v5(140.93,159.89) 141.39,160.35 CPU1.F39
  BOTTOM w0.089: v5(140.93,159.89) 140.69,160.13 140.69,160.73 140.87,160.91 142.54,160.91 144.64,163.01 144.71,163.01 144.73,163.03
  BOTTOM w0.203: 144.73,163.03 145.84,164.14 145.84,167.08 147.78,169.01 152.98,169.01 166.47,182.5 166.47,191.26 166.04,191.69 166.04,196.61 167.28,197.85 167.28,199.57 166.82,200.03 166.07,200.03 165.63,199.59 165.63,199.11 v1(165.38,198.86)
VCORE_READY: length 203.2
  TOP w0.102: U19.11 168.5,212.8 168.58,212.72 169.27,212.72 169.8,213.26 170.41,213.26 171.04,213.89 172.34,213.89 172.52,214.07 175.21,214.07 175.59,213.69 178.08,213.69 179.01,212.76 R156.1 179.01,209.89 179.73,209.17 179.73,207.98 180.64,207.06 186,207.06 v1(186.74,206.32) ; v1(192.71,46.38) 192.63,46.46 R536.2
  BOTTOM w0.102: v1(186.74,206.32) 188.09,206.32 190.34,204.07 196.69,204.07 197.99,202.77 197.99,118.08 197.21,117.29 197.21,114.59 197.54,114.26 197.54,92.35 186.46,81.28 186.46,75.84 188.37,73.94 188.37,57.48 190.32,55.52 v2(191.36,55.52) 192.1,54.79 192.1,54.13 192.89,53.34 192.89,46.56 v1(192.71,46.38)
VCORE_SENS: length 120.4
  TOP w0.203: C71.1 166.47,219.89 v1(166.47,220.34) ; v5(140.9,162.67) CPU1.C38 ; C49.2 167.63,222.37 v1(167.92,222.66) 167.92,223.09 C38.2 167.42,224.5 C644.1 R45.1 166.09,225.39 R37.1
  BOTTOM w0.203: v5(140.9,162.67) 140.64,162.92 140.64,163.19 140.85,163.4 143.41,163.4 144.53,164.52 144.53,167.46 147.22,170.15 151.65,170.15 152.86,171.36 152.86,173.6 153.13,173.87 SR14.2 153.13,174.72 152.86,174.99 152.86,176.63 154.25,178.03 160.42,178.03 165.35,182.97 165.35,189.63 164.45,190.54 164.45,199.55 164.94,200.04 165.7,200.8 166.07,200.8 168.14,202.87 169.74,202.87 170.7,203.84 173.2,203.84 175.06,205.69 177.27,205.69 178.54,206.96 183.94,206.96 185.67,208.69 185.67,215.06 182.83,217.91 182.12,217.91 181.12,218.91 178.38,221.64 176.79,221.64 174.12,224.31 170.62,224.31 169.27,222.95 169.27,222.68 169.04,222.45 168.12,222.45 v1(167.92,222.66) 167.77,222.5 167.23,222.5 166.47,221.74 v1(166.47,220.34)
VGA_BLUE: length 9.6
  TOP w0.102: U7.7 184.97,227.29 184.45,226.77 182.14,226.77 181.56,227.36 181.56,228.99 R26.1 C10.1 FB1.1
VGA_BLUE_CONN: length 13
  TOP w0.102: VGA.3 179.91,236.77 U2.3 180.99,234.33 181.56,233.76 181.56,232.92 180.16,231.52 178.08,231.52 177.57,231.01 C9.1 FB1.2
VGA_DDCCLK_CNN: length 33.5
  TOP w0.102: VGA.15 184.45,243.08 172.19,243.08 170.79,241.68 170.79,238.76 169.39,237.36 169.39,235.48 167.94,234.04 167.94,232.28 168.35,231.88 169.42,231.88 169.67,232.13 169.91,232.13 U1.3 170.22,232.61 v1(169.09,232.61)
  BOTTOM w0.102: SR3.2 171,232.49 SR1.2 SC2.1 169.12,232.64 v1(169.09,232.61)
VGA_DDCSDA_CNN: length 24
  TOP w0.102: v1(168.45,233.02) 168.45,233.81 168.97,234.33 170.3,234.33 U1.1 170.3,235.64 169.96,235.98 169.96,237.55 171.04,238.63 171.04,241.55 172.31,242.82 177.83,242.82 VGA.12
  BOTTOM w0.102: SR4.2 170.99,231.37 SR5.2 SC4.1 169.02,231.51 168.45,232.08 v1(168.45,233.02)
VGA_GREEN: length 7.9
  TOP w0.102: FB2.1 C22.1 R29.1 180.87,227.18 181.89,226.16 184.35,226.16 185.08,226.89 U7.8
VGA_GREEN_CONN: length 12.9
  TOP w0.102: VGA.2 178.64,237.78 178.64,232.71 178.35,232.43 U2.6 177.05,232.43 176.83,232.21 176.83,228.63 177.32,228.14 C21.1 FB2.2
VGA_HSYNC: length 35
  TOP w0.102: v1(182.47,233.43) 183.06,232.84 184.25,232.84 185.14,231.95 185.14,229.69 185.54,229.29 U7.2 ; R24.1 166.88,231.09 165.96,230.17 165.96,228.65 166.42,228.19 U5.2 U5.1 169.31,227.04 169.86,226.49 174.5,226.49 174.73,226.72 174.73,228.24 174.96,228.47 174.96,230.12 174.27,230.81 v1(174.27,231.62)
  BOTTOM w0.102: v1(174.27,231.62) 175.03,232.38 v2(175.03,232.66) 175.03,233.15 175.84,233.96 181.94,233.96 v1(182.47,233.43)
VGA_HSYNC_5V: length 2.3
  TOP w0.102: R25.1 R24.2 166.83,230.29 U5.4
VGA_HSYNC_CNN: length 20.7
  TOP w0.102: VGA.13 180.22,241.07 179.22,241.07 179.02,240.87 178.41,240.87 178.21,241.07 177.01,241.07 176.38,240.44 176.38,239.62 174.32,237.57 174.32,234.7 174.05,234.43 U1.6 172.45,234.43 171.81,233.78 171.81,232.28 171.42,231.9 170.01,231.9 C8.1 R25.2
VGA_RED: length 7.9
  TOP w0.102: U7.9 185.42,226.49 184.45,225.53 182.4,225.53 181.62,224.75 R40.1 C29.1 FB3.1
VGA_RED_CONN: length 16.2
  TOP w0.102: FB3.2 C28.1 176.91,226.36 176.91,227.48 176.23,228.17 176.23,231.24 175.39,232.08 175.39,233.55 176.16,234.33 U2.4 177.41,236.95 VGA.1
VGA_VSYNC: length 30.9
  TOP w0.102: v1(174.27,232.36) 173.79,231.88 173.79,230.96 174.73,230.02 174.73,228.68 174.24,228.19 U6.2 U6.1 173.86,227.04 173.54,226.72 170.54,226.72 170.31,226.95 170.31,229.49 169.93,229.87 169.93,230.78 R22.1 ; v1(183.21,233.43) 183.57,233.07 184.35,233.07 185.37,232.05 185.37,229.9 185.58,229.69 U7.1
  BOTTOM w0.102: v1(174.27,232.36) 174.27,232.71 175.74,234.19 v2(182.83,234.19) 183.21,233.81 v1(183.21,233.43)
VGA_VSYNC_5V: length 2.3
  TOP w0.102: R22.2 R23.1 171.53,229.29 U6.4
VGA_VSYNC_CNN: length 20.1
  TOP w0.102: VGA.14 182.25,240.82 179.32,240.82 179.1,240.59 178.36,240.59 178.13,240.82 177.11,240.82 176.63,240.33 176.63,239.55 174.55,237.46 174.55,233.63 173.45,232.53 U1.4 172.8,231.9 173,231.7 C7.1 R23.2
VR_ENABLE: length 903.3
  TOP w0.102: U22.3 95.22,200.53 v1(95.1,200.66) ; v1(75.31,78.66) 75.06,78.92 61.09,78.92 60.4,78.23 56.29,78.23 53.85,80.67 53.85,84.2 47.83,90.22 47.83,93.5 46.69,94.64 46.69,99.26 48.82,101.4 50.37,101.4 51.17,102.2 52.72,102.2 57.12,106.6 57.12,112.01 57.89,112.78 60.71,112.78 69.01,121.08 R325.1 ; v1(197.18,122.68) 199.06,124.56 199.06,190.07 198.25,190.88 198.25,202.44 196.65,204.04 189.53,204.04 v1(188.57,205) ; R687.2 148.39,27.26 v1(148.39,21.06) 149.73,19.71 149.73,7.95 v1(149.94,7.75) ; v1(101.68,40.84) 101.57,40.94 101.57,50.24 v1(100.94,50.88) ; v1(135.86,209.68) 129.26,209.68 127.13,211.81 123.95,211.81 121.44,209.3 v1(121.13,209.3) ; R690.2 162.31,27.44 162.31,8.03 v1(162.05,7.77) ; v1(8.71,12.65) 8.51,12.85 1.68,12.85 0.56,13.97 0.56,123.18 C350.2 4.94,126.43 Q14.C ; v1(120.88,5.94) v1(120.88,4.17) ; v1(185.37,205.33) 184.53,206.17 180.31,206.17 178.77,207.72 178.77,209.07 178.16,209.68 178.16,209.78 177.5,210.44 177.5,211.26 R143.1 176.49,212.27 170.13,212.27 169.72,211.86 v1(169.72,211.53)
  TOP w0.203: C127.1 169.65,210.79 168.84,211.6 U19.8
  TOP w0.254: C127.1 170.01,211.25 v1(169.72,211.53)
  BOTTOM w0.102: v1(135.86,209.68) 136.47,210.29 145.08,210.29 149.48,214.68 155.5,214.68 156.62,215.8 161.75,215.8 162.53,215.01 168.58,215.01 169.72,213.87 v1(169.72,211.53) ; v1(120.88,5.94) 120.65,5.72 116.03,5.72 114.48,4.17 107.98,4.17 106.12,6.02 103.2,6.02 100.69,3.51 79.98,3.51 78.89,4.6 77.55,4.6 77.04,4.09 53.87,4.09 53.24,4.72 47.99,4.72 46.63,6.08 46.63,10.21 44.4,12.45 42.54,12.45 41.76,13.23 39.5,13.23 38.94,13.79 32.96,13.79 31.18,12.01 28.98,12.01 27.79,10.82 10.13,10.82 8.71,12.24 v1(8.71,12.65) ; v1(101.68,40.84) 101.4,40.56 101.4,39.57 102.08,38.89 104.8,38.89 107.92,35.76 117.09,35.76 118.54,34.32 119.91,34.32 120.9,35.31 122.91,35.31 129.69,28.52 131.17,28.52 138.51,21.18 148.26,21.18 v1(148.39,21.06) ; v1(197.18,122.68) 197.18,117.6 196.98,117.4 196.98,114.43 197.31,114.1 197.31,92.45 186.23,81.37 186.23,75.74 188.14,73.84 188.14,57.07 190.07,55.14 190.88,55.14 191.82,54.2 191.82,53.95 192.63,53.14 192.63,49.53 185.72,42.62 185.72,23.16 170.56,8 162.28,8 v1(162.05,7.77) 161.98,7.85 v2(151.23,7.85) 150.04,7.85 v1(149.94,7.75) 149.68,7.49 139.34,7.49 138.91,7.92 138.91,11.18 132.54,17.55 125.3,17.55 124.71,16.97 124.71,15.85 125.15,15.42 125.15,6.32 122.99,4.17 v1(120.88,4.17) ; v1(185.37,205.33) 185.7,205 v1(188.57,205) ; v1(100.94,50.88) 99.75,52.07 99.75,59.39 104.65,64.29 104.65,77.29 102.77,79.17 94.39,79.17 93.62,79.93 76.58,79.93 v1(75.31,78.66) ; v1(95.1,200.66) 96.49,200.66 98.27,202.44 100.81,202.44 105.13,206.76 110.39,206.76 112.93,209.3 v1(121.13,209.3)
VR_ENABLE_R: length 16.3
  TOP w0.102: QN28.3 134.58,28.29 R692.1 v1(136.75,29.43) 137.73,30.4 142.53,30.4 QN30.3 144.99,28.42 R686.1 R687.1
VR_HOT_L: length 52.7
  TOP w0.102: R159.1 175.95,208.79 174.98,208.79 174.73,208.53 v1(173.48,208.53) 171.56,208.53 170.85,209.25 169.44,209.25 168.69,210 U19.4
  BOTTOM w0.102: v1(173.48,208.53) 173.08,208.53 171.42,206.88 170.51,206.88 168.86,205.23 167.48,205.23 164.16,201.92 164.16,201.58 161.9,199.32 161.9,194.06 151.66,183.82 v2(151.66,182.98) 151.66,179.2 SR9.2 SC16.1 SR13.1
VR_READY: length 462.3
  TOP w0.102: v1(192.05,53.01) 192.07,52.98 192.87,52.98 R497.1 192.89,52.91 BT3.3 ; Q17.C 0.79,118.64 0.79,14.35 1.8,13.34 v1(3.99,13.34) ; R342.1 v1(195.74,115.32) ; R724.1 49.82,22.51 R725.1 50.39,22.13 50.39,21.59 51.65,20.33 51.65,19.29 51.79,19.15 51.79,18.29 51.08,17.58 51.08,16.33 50.19,15.44 48.44,15.44 47.93,15.95 46.15,15.95 45.54,15.34 45.54,12.65 v1(43.84,10.95)
  BOTTOM w0.102: v1(3.99,13.34) v2(3.99,11.86) 3.99,9.47 4.6,8.86 9.52,8.86 9.86,9.19 30.76,9.19 33.63,12.06 38.68,12.06 39.85,10.9 42.11,10.9 42.52,11.3 43.48,11.3 v1(43.84,10.95) 44.27,10.95 45.49,9.73 45.49,5.46 47.4,3.56 52.68,3.56 53.7,2.54 101.12,2.54 103.66,5.08 105.13,5.08 107.09,3.12 114.83,3.12 116.38,4.67 123.16,4.67 124.92,6.43 124.92,15.29 124.49,15.72 124.49,17.17 125.17,17.86 132.64,17.86 141.83,8.66 149.99,8.66 152.2,10.87 153.21,10.87 155.73,8.36 170.51,8.36 185.45,23.3 185.45,42.86 191.77,49.17 191.77,52.73 v1(192.05,53.01) 191.54,53.52 191.54,54.1 190.88,54.76 190.07,54.76 187.91,56.92 187.91,73.74 186,75.64 186,81.48 197.08,92.56 197.08,113.51 195.74,114.85 v1(195.74,115.32)
VRALERT_L: length 10.2
  TOP w0.089: PCH1.BD23 61.47,43.2 60.96,42.69 60.96,41.96 61.59,41.33 61.59,38.99
  TOP w0.102: 61.59,38.99 61.14,38.53 61.14,37.64 60.96,37.47 60.96,34.74 R626.1
VRD_THERMDA: length 410.1
  TOP w0.178: U38.45 117.61,35.84
  TOP w0.254: v1(127.94,15.24) 127.81,15.11 127.56,15.11 127.28,15.39 127.28,23.65 126.14,24.79 126.14,30.62 128.14,32.62 128.14,35.79 127.08,36.86 124.84,36.86 124.31,37.39 123.18,37.39 C582.1 122.26,36.7 118.48,36.7 117.61,35.84 ; Q9.C 126.47,206.88 Q9.B 126.08,208.54 C136.1 126.08,210.15 v1(126.05,210.18)
  BOTTOM w0.254: v1(126.05,210.18) 125.93,210.3 125.93,211.2 126.16,211.43 129.06,211.43 130.56,212.93 143.97,212.93 148.51,217.47 153.47,217.47 154.71,218.72 158.01,218.72 162.92,223.62 168.78,223.62 170.33,225.17 174.42,225.17 177.09,222.5 178.64,222.5 181.08,220.07 185.11,220.07 187.6,217.57 187.6,208.3 190.93,204.98 197.1,204.98 198.78,203.3 198.78,92.13 187.63,80.98 187.63,76.23 192.84,71.02 192.84,66.83 190.07,64.06 190.07,59.81 194.36,55.52 194.36,41.88 187.1,34.62 187.1,9.48 182.55,4.93 137.82,4.93 136.47,6.28 136.47,7.7 v2(136.73,7.95) 136.47,8.2 136.47,11.43 132.77,15.14 128.04,15.14 v1(127.94,15.24)
VRD_THERMDC: length 404.1
  TOP w0.254: R617.2 122.72,36.21 C582.2 123.34,36.83 124.08,36.83 124.61,36.3 126.85,36.3 127.58,35.56 127.58,32.85 125.58,30.85 125.58,24.56 126.72,23.42 126.72,15.16 127.33,14.55 127.79,14.55 v1(127.89,14.45) ; v1(125.1,210.18) 125.13,210.15 C136.2 125.13,208.85 124.43,208.15
  BOTTOM w0.254: v1(127.89,14.45) 128.02,14.58 132.53,14.58 135.92,11.2 135.92,9.73 v2(135.74,9.55) 135.92,9.37 135.92,6.05 137.59,4.37 182.78,4.37 187.66,9.25 187.66,34.39 194.92,41.65 194.92,55.75 190.63,60.05 190.63,63.83 193.4,66.6 193.4,71.25 188.19,76.46 188.19,80.75 199.34,91.9 199.34,203.53 197.33,205.54 191.16,205.54 188.16,208.53 188.16,217.81 185.34,220.62 181.31,220.62 178.87,223.06 177.32,223.06 174.65,225.73 170.1,225.73 168.55,224.18 162.68,224.18 157.78,219.28 154.48,219.28 153.24,218.03 148.28,218.03 143.74,213.49 130.32,213.49 128.83,211.99 125.93,211.99 125.37,211.43 125.37,210.45 v1(125.1,210.18)
VREF: length 4.1
  TOP w0.254: CODEC.27 19.89,223.09 20.08,223.28
  TOP w0.508: 20.08,223.28 20.08,223.58 20.68,224.18 C24.1
VSA_BST: length 2
  TOP w0.305: 96.69,196.28 96.22,196.74 U22.10
  TOP w0.635: R230.1 97.13,195.83 96.69,196.28
VSA_BST_R: length 1.7
  TOP w0.508: C211.2 96.02,193.55 R230.2
VSA_CS: length 2.1
  TOP w0.254: U22.2 95.72,200.81 96.37,201.45 R198.1
VSA_FB: length 4.2
  TOP w0.254: U22.4 94.72,200.22 94.21,200.74 R196.1 ; R196.1 R197.1 ; R196.1 R195.1
VSA_FB_R: length 8
  TOP w0.254: 91.29,201.77 C180.2 93.1,203.58 C173.2 94.37,202.56 R196.2 ; 91.29,201.77 91.29,201.32 91.92,200.69 R215.2 ; 91.29,201.77 91.29,201.9 R192.2
VSA_FB_RC: length 1.5
  TOP w0.254: R195.2 92.88,202.41 C180.1
VSA_GSENS: length 113.4
  TOP w0.102: v1(51.56,134.19) 51.84,134.47 57.56,134.47 58.14,135.05 61.77,135.05 67.21,140.49 72.24,140.49 R300.2 ; R203.2 89.34,201.75 86.84,201.75 79.71,194.61 v1(79.71,193.9)
  BOTTOM w0.102: v1(79.71,193.9) 79.02,193.22 77.34,193.22 76.28,192.15 76.28,190.68 74.5,188.9 74.5,185.37 73.11,183.98 72.07,183.98 v2(71.73,183.64) 71.39,183.98 69.66,183.98 62.59,176.91 61.7,176.91 51.03,166.24 51.03,134.72 v1(51.56,134.19)
VSA_LG: length 13
  TOP w0.254: v1(93.45,196.6) 93.83,196.97 U22.6
  TOP w0.635: QCSL1.G v1(101,192.41)
  BOTTOM w0.635: v1(101,192.41) v2(99.72,192.41) 94.92,192.41 93.45,193.88 v1(93.45,196.6)
VSA_PH: length 10.9
  TOP w0.305: v1(95.1,195.83) 95.22,195.96 U22.8
  TOP w0.508: C211.1 95.1,195.42 v1(95.1,195.83)
  BOTTOM w0.635: v1(95.1,195.83) 95.1,195.07 95.94,194.23 102.59,194.23
  vias: v1(102.82,192) v1(102.77,189.36) v1(104.04,189.97) v1(105.66,191.82) v1(105.69,188.29) v1(107.44,189.94) v1(107.82,198.3) v1(108.2,197.1) v1(108.25,195.4) v1(108.25,193.55) v1(108.41,191.87) v1(109.5,190.42)
VSA_PWRGD: length 3.7
  TOP w0.102: R199.1 R200.1
  TOP w0.254: R199.1 97.1,200.91 96.49,200.91 96.22,200.64 U22.1
VSA_READY: length 278.6
  TOP w0.102: BT3.2 195.17,52.74 C529.2 193.71,54.71 v1(192.63,54.71) ; v1(169.11,213.26) 169.34,213.49 170.28,213.49 170.92,214.12 172.24,214.12 172.42,214.3 175.39,214.3 175.77,213.92 178.21,213.92 179.5,212.62 179.5,209.73 179.96,209.27 179.96,208.15 180.82,207.29 186.77,207.29 v1(186.99,207.06) ; R200.2 100.91,202.41 101.96,203.45 101.96,205.61 103.66,207.31 110.77,207.31 113.32,209.87 121.65,209.87 123.82,212.04 127.48,212.04 129.08,210.44 136.35,210.44 v1(137.11,209.68)
  BOTTOM w0.102: v1(169.11,213.26) 169.11,214 168.5,214.6 162.53,214.6 161.67,215.47 156.77,215.47 155.68,214.38 149.53,214.38 145.21,210.06 137.49,210.06 v1(137.11,209.68) ; v1(192.63,54.71) 192.63,55.22 190.75,57.1 v2(190.14,57.1) 189.26,57.1 188.59,57.76 188.59,74.04 186.69,75.95 186.69,81.18 197.76,92.25 197.76,114.35 197.43,114.68 197.43,117.2 198.22,117.98 198.22,202.92 196.8,204.34 190.45,204.34 187.73,207.06 v1(186.99,207.06)
VSA_READY_R: length 3.2
  TOP w0.102: BT3.1 193.78,48.13 C538.2 R536.1
VSA_RF: length 1.2
  TOP w0.254: U22.5 93.28,199.77 R216.1
VSA_SENS: length 159.3
  TOP w0.102: v1(51.05,133.65) 51.1,133.6 51.66,133.6 52.3,134.24 57.68,134.24 58.27,134.82 61.87,134.82 67.3,140.26 71.7,140.26 73.25,138.71 73.25,136.93 73.91,136.27 73.91,135.61 v1(73.71,135.41) ; R192.1 89.34,201.98 86.74,201.98 78.94,194.18 v1(78.94,193.88)
  TOP w0.203: CPU1.AD5 v5(107.64,145.29)
  BOTTOM w0.102: v1(51.05,133.65) 50.8,133.91 50.8,166.37 61.57,177.14 62.48,177.14 69.58,184.24 73.01,184.24 74.23,185.46 74.23,188.98 76.02,190.77 76.02,192.25 77.65,193.88 v1(78.94,193.88)
  BOTTOM w0.203: v1(73.71,135.41) 74.52,135.41 76.94,137.82 83.29,137.82 v2(84.38,136.73) 84.4,136.7 85.75,136.7 95.05,146 106.78,146 107.49,145.29 v5(107.64,145.29)
VSA_UG: length 27.3
  TOP w0.305: v1(95.99,195.83) 95.72,196.1 U22.9
  TOP w0.635: v1(110.21,193.68) 110.21,194.56 R227.1
  BOTTOM w0.635: v1(110.21,193.68) v2(110.21,195.58) 110.21,199.72 108.41,201.52 99.26,201.52 97.54,199.8 97.54,197.38 v1(95.99,195.83)
VSA_VDD: length 4.1
  TOP w0.305: U22.7 94.72,196.53 94.21,196.01 94.21,195.17 C210.2
  TOP w0.508: R229.1 93.61,194.91 C210.2
VSUMA+: length 42.3
  TOP w0.203: v1(172.39,219.79) 172.14,219.53 170.01,219.53 R95.2 169.27,218.79 169.27,217.88 167.34,215.95 167.08,215.95 165.87,214.74 U19.18
  TOP w0.254: R114.1 v1(182.47,215.14) ; v1(180.59,208.36) 180.59,208.25 181.1,207.75 181.91,207.75 R163.1 ; v1(176.25,218.95) 175.95,218.65 R91.1 ; C39.2 C40.2 172.03,222.17 R70.2 172.07,222.04 172.64,221.46 172.64,220.04 v1(172.39,219.79)
  BOTTOM w0.254: v1(172.39,219.79) 172.62,219.56 175.64,219.56 v1(176.25,218.95) 179.5,215.7 181.91,215.7 v1(182.47,215.14) 182.47,213.36 184.51,211.33 184.51,209.27 183.6,208.36 v2(183.18,208.36) v1(180.59,208.36)
VSUMA-: length 133.8
  TOP w0.203: R97.1 180.38,218.47 R96.1 C74.1 v1(178.1,218.47) ; R71.1 173.37,220.93 v1(173.94,220.93) 173.94,220.17 174.27,219.84 R90.1 C70.1 ; C40.1 C39.1 170.49,224.5 R46.2 170.05,223.97 170.05,222.35 C53.2 169.49,221.02 169.49,220.7 169.04,220.24 v1(169.04,220.23) 169.04,219.78 R94.2
  TOP w0.254: v1(183.74,213.82) 183.32,213.39 R128.1 ; R147.1 R128.1 ; R128.1 C109.1 ; RT2.2 v1(121.93,181.61) ; C53.2 170.66,221.96 171.32,221.31 171.68,221.31 R70.1 171.63,220.81 v1(171.63,220.37)
  BOTTOM w0.203: v1(169.04,220.23) 169.04,219.68 168.66,219.3 163.86,219.3 163.3,219.86 160.25,219.86 158.34,217.96 155.18,217.96 153.89,216.66 148.76,216.66 144.29,212.19 131.62,212.19 123.01,203.58 119.27,203.58 118.36,202.68 118.36,201.48 117.49,200.61 114.62,200.61 111.3,197.29 111.3,191.71 111.02,191.43 111.02,184.07 113,182.09 121.44,182.09 v1(121.93,181.61)
  BOTTOM w0.254: v1(183.74,213.82) 183.74,215.24 182.42,216.56 180.01,216.56 178.1,218.47 v1(178.1,218.47) 178.1,218.62 175.79,220.93 v1(173.94,220.93) 173.76,220.75 v2(172.97,220.75) 172.01,220.75 v1(171.63,220.37)
VSUMB+: length 19.6
  TOP w0.203: U19.50 166.67,207.32 168.17,205.82
  TOP w0.254: R211.1 173.99,200.76 173.99,200.76 173.61,201.14 ; v1(173.61,201.47) 173.61,201.14 ; 173.61,201.14 173.22,200.76 R210.2 ; 168.17,205.82 168.17,202.59 167.77,202.18 C178.2 R205.2 v1(168.38,201.04) ; C174.2 171.86,202.83 171.86,201.73 v1(171.68,201.55) R209.2
  BOTTOM w0.254: v1(168.38,201.04) 168.38,201.68 168.83,202.13 170.51,202.13 171.09,201.55 v1(171.68,201.55) 171.75,201.47 v2(172.69,201.47) v1(173.61,201.47)
VSUMB-: length 125.2
  TOP w0.152: v1(171.93,146.74) 171.89,146.69 RT4.2
  TOP w0.254: R178.1 167.41,204.25 167.41,203.5 R186.1 167.58,203.27 166.63,202.32 C178.1 R205.1 167.14,200.53 167.65,200.53 C193.2 168.38,199.8 R207.1 169.93,199.26 172.03,199.26 172.44,199.67 172.44,200.96 172.64,201.17 172.64,202.74 R189.1 C168.1 ; C167.1 R179.1 170.69,205.45 171.63,204.52 C174.1 171.65,204.03 172.73,204.03 C168.1 ; C168.1 R180.1 v1(175.18,204.5) ; v1(176.66,204.7) 179.22,204.7 v1(180.06,203.86)
  BOTTOM w0.152: v1(171.93,146.74) 172.16,146.96 172.62,146.96 173.33,147.68 181.84,147.68 182.12,147.95 185.83,147.95 187.17,146.61 193.95,146.61 196.65,149.3 196.65,201.14 195.78,202.01 188.72,202.01 187.55,203.17 182.95,203.17 182.52,203.61 180.49,203.61 180.24,203.86 v1(180.06,203.86)
  BOTTOM w0.254: v1(175.18,204.5) 175.39,204.7 v1(176.66,204.7)
VTT_CNTL_D: length 6.7
  TOP w0.102: R322.2 188.03,123.26 QN15.1 186.23,124.05 186.23,125.65 v1(185.83,126.06) 185.14,126.75 QN14.D
VTT_CNTL_G: length 8
  TOP w0.102: QN14.G v1(186.39,127.79) 185.5,128.68 184.2,128.68 183.7,128.17 R311.2
W_DISABLE: length 42.7
  TOP w0.102: v1(25.63,105.99) 25.04,106.58 v1(19.43,106.58) ; M2_1.56 32.69,119.55 32.11,118.97 30.76,118.97 30.28,119.46 v1(30,119.46) ; v1(26.47,100.66) 26.52,100.71 29.74,100.71 30.86,99.59 32.44,99.59 32.99,99.03 R370.2 R371.2
  BOTTOM w0.102: v1(30,119.46) 29.92,119.46 29.69,119.23 29.69,117.48 19.81,107.59 19.81,106.96 v1(19.43,106.58) ; v1(26.47,100.66) 26.37,100.76 v2(26.37,101.68) 26.57,101.88 26.57,105.05 v1(25.63,105.99)
WBT_LED_P1: length 4.9
  TOP w0.102: R730.1 32.16,20.8 31.32,19.96 30.1,19.96 29.3,19.16 WBT_LED.1
WBT_LED_P2: length 3.2
  TOP w0.102: WBT_LED.3 34.3,18.97 34.82,19.5 R731.1
WBT_LED_P4: length 6.5
  TOP w0.102: Q36.E 37.9,23.93 37.9,20.83 37.64,20.57 37.64,18.92 WBT_LED.4
WFLED-: length 16.2
  TOP w0.102: WBT_LED.2 32.8,17.07 34.65,17.07 35.26,17.68 35.26,19.05 36.68,20.47 36.68,23.01 36.58,23.11 36.58,24.84 36.83,25.1 37.41,25.1 38.23,25.91 38.23,26.85 37.82,27.25 Q34.E
WLAN_100M_N: length 93.7
  TOP w0.089: v3(53.63,60.31) 53.41,60.09 PCH1.L7
  TOP w0.102: M2_1.49 34.44,112.3 34.62,112.12 34.62,106.43 33.43,105.23 33.15,105.23 v2(32.82,105.56) 32.49,105.23 31.88,105.23 v3(31.6,105.51)
  BOTTOM w0.102: v3(53.63,60.31) 53.49,60.31 53.35,60.45 53.35,60.67 53.1,60.92 52.51,60.92 51,59.41 40.45,59.41 36.18,55.14 28.91,55.14 27.65,56.4 27.65,57.2 26.31,58.53 26.31,71.54 26.01,71.84 26.01,83.26 32.49,89.74 32.49,105.01 32.27,105.23 31.88,105.23 v3(31.6,105.51)
WLAN_100M_P: length 93.7
  TOP w0.089: PCH1.L5 52.65,60.09 v3(52.87,60.31)
  TOP w0.102: v3(31.6,104.72) 31.91,105.03 33.51,105.03 34.12,105.64 v2(34.59,105.64) 34.59,106.11 34.82,106.34 34.82,112.22 34.94,112.33 M2_1.47
  BOTTOM w0.102: v3(52.87,60.31) 53,60.31 53.15,60.45 53.15,60.59 53.02,60.71 52.59,60.71 51.09,59.21 40.53,59.21 36.27,54.94 28.82,54.94 27.44,56.32 27.44,57.11 26.11,58.45 26.11,71.45 25.81,71.76 25.81,83.35 32.28,89.82 32.28,104.93 32.18,105.03 31.91,105.03 v3(31.6,104.72)
WLAN_SW: length 5.1
  TOP w0.102: QN12.1 58.46,130.79 v1(58.46,130.07) 58.46,128.41 57.78,127.73 C349.1 R312.2
WLAN_SW_C: length 6.8
  TOP w0.203: QN12.3 57.06,128.35 55.75,128.35 R310.1 54.2,129.89 v2(54.18,129.89) R308.2 R307.1
XCLK_BIASREF: length 9.6
  TOP w0.102: PCH1.E1 49.56,62.68 48.36,63.88 48.36,68.66 49.07,69.36 R409.2
XDP_BPM_0: length 49.8
  TOP w0.102: CPU1.D16 v5(118.6,163.58)
  BOTTOM w0.102: v5(118.6,163.58) 118.18,164 118.18,164.84 118.49,165.15 118.49,168.88 110.99,176.38 103.69,176.38 100.31,179.76 81.91,179.76 80.7,180.97 STP4.1
XDP_BPM_1: length 48.3
  TOP w0.102: v5(119.52,163.56) CPU1.D17
  BOTTOM w0.102: STP7.1 82.58,180.11 100.46,180.11 103.84,176.73 111.15,176.73 119.53,168.35 119.53,165.3 119.08,164.85 119.08,164 v5(119.52,163.56)
XDP_BPM_2: length 1.6
  TOP w0.102: CPU1.G14 v5(116.79,159.92)
  BOTTOM w0.089: STP28.1 115.9,159.92 v5(116.79,159.92)
XDP_BPM_3: length 1.6
  TOP w0.102: CPU1.H14 v5(116.79,159)
  BOTTOM w0.089: v5(116.79,159) 116.51,158.72 STP30.1
XTAL_24M_IN: length 9.6
  TOP w0.102: PCH1.A6 52.83,64.82 52.68,64.82 52.35,65.15 51.38,65.15 50.39,66.14 50.04,66.14 49.66,65.76 v3(49.66,65.56)
  BOTTOM w0.102: SR36.2 48.56,64.47 v3(49.66,65.56)
XTAL_24M_OUT: length 21.6
  TOP w0.102: PCH1.A5 52.22,64.92 51.28,64.92 50.55,65.66 v3(50.29,65.66)
  BOTTOM w0.102: SY1.1 33.52,63.41 33.83,63.09 37.18,63.09 SC42.1 38.15,64.07 SR17.2 39.35,63.88 48.39,63.88 49.66,65.15 49.89,65.15 50.29,65.56 v3(50.29,65.66)
N15926147: length 2.7
  TOP w0.102: CLR_CMOS.3 186.79,65.79 R427.1
N15926841: length 2.7
  TOP w0.102: v2(194.36,65.37) R434.1 193.4,66.83 D17.2
N15926845: length 3.9
  TOP w0.102: R433.2 R431.1 191.11,66.83 D17.1 191.17,67.16 v1(190.32,67.16)
N15932147: length 18.1
  TOP w0.102: v1(44.1,18.8) QN35.1 43.4,17.26 42.54,18.11 42.54,19.25 43.98,20.68 QN33.1 ; v1(49.2,14.96) 48.44,14.96 48.14,15.26 QN36.3 46.58,14.13 R741.2
  BOTTOM w0.102: v1(49.2,14.96) 47.29,16.87 v2(47.29,16.97) 47.29,17.48 45.72,19.05 44.36,19.05 v1(44.1,18.8)
N15932439: length 3.7
  TOP w0.102: R736.2 48.51,16.11 47.53,17.08 QN36.1 47.53,17.74 QN34.3
N17027396: length 1.6
  TOP w0.102: Q16.B 54.84,128.3 R310.2
N17027596: length 9.7
  TOP w0.102: R306.2 50.14,128.3 Q15.C v2(50.14,124) 50.5,123.65 50.5,122.56 C359.1 50.01,121.54 50.39,121.16 QSW2.4
N17027830: length 8.6
  TOP w0.102: R318.2 56.08,125.86 54.46,125.86 Q16.C 53.82,124.54 v2(53.29,124) 53.29,122.51 C360.1 52.86,121.46 52.93,121.39 QSW2.2
N17238456: length 4.3
  TOP w0.102: v1(185.72,123.22) 185.72,123.49 185.03,124.19 QN15.3 R321.1 183.58,124.05 R326.2
N17804039: length 2.5
  TOP w0.102: v2(157.15,222.76) 157.28,222.89 R50.1 158.41,223.16 QN3.G
N17804048:
  vias: v2(164.62,226.34)
N18832986: length 2.8
  TOP w0.254: Q35.C 194.47,30.29 RN12.7
  vias: v1(194.84,28.91)
N18833027: length 4.9
  TOP w0.102: R757.1 24.1,8.82 24.1,5.46 F_PANEL.11
N18833215: length 4.1
  TOP w0.102: v2(191.59,27.13) C614.2
  TOP w0.254: Q35.B 192.79,26.7 R705.2 C614.2
N18833356: length 19.8
  TOP w0.254: R501.2 R477.1 v1(173.6,54.26)
  BOTTOM w0.254: Q22.B 175.51,69.6 173.6,67.68 v1(173.6,54.26)
N18833892: length 2.4
  TOP w0.102: F_PANEL.14 25.25,7.62 Q38.E
N18833899: length 2.4
  TOP w0.102: F_PANEL.12 23.37,7.26 23.37,8.47 R755.2
N18833970: length 2.2
  TOP w0.102: R756.2 15.6,8.44 F_PANEL.6
N18833998: length 2.6
  TOP w0.102: v1(10.36,11.53) 10.52,11.38 11.2,11.38 Q37.B 11.38,12.86 R745.1
N18834219: length 2.8
  TOP w0.102: v2(173.54,55.21) R477.2
  TOP w0.254: U34.1 174.47,56.86 R477.2
N19174289: length 8.7
  TOP w0.305: v3(56.93,44.66) PCH1.BA15
  TOP w0.508: R615.1 55.78,38 v1(56.01,38.23)
  BOTTOM w0.381: v1(56.01,38.23) 56.43,38.65 56.43,42.67 56.77,43 v2(56.77,43.81) 56.77,44.5 v3(56.93,44.66)
N19734777: length 3.6
  TOP w0.102: C551.2 v1(146.06,43.69)
  TOP w0.254: R554.1 C551.2 146.06,45.66 Q30.G
N19734802: length 3.6
  TOP w0.102: v1(154.61,55.98) 154.53,55.98 R462.1
  TOP w0.254: Q27.G 152.76,57.91 C522.2 R462.1
N19735370: length 10.7
  TOP w0.102: R424.1 163.17,66.26 163.17,64.74 R441.2 ; R424.1 164.76,65.94 R425.2 ; R424.1 162.88,67.82 Q24.C 160.34,66.9 v1(159.59,66.9) R423.2
N19735374: length 5.7
  TOP w0.102: C493.2 159.01,63.94 R438.2 158.07,63.32 v2(157.89,63.32) ; C493.2 160.28,64.1 R439.2 ; C493.2 160.12,65.41 Q24.B
N19735396: length 5.2
  TOP w0.102: R423.1 158.72,65.53 157.96,64.77 156.95,64.77 v1(156.21,65.51) 155.04,66.68
N19735409: length 3.8
  TOP w0.102: Q26.B 165.33,63.88 v2(165.18,64.03) 163.8,65.41 R424.2
N19808359: length 5.6
  TOP w0.102: QN21.3 v1(138.55,61.14)
  TOP w0.254: R447.2 C496.1 136.88,60.74 Q28.G 138.29,59.94 QN21.3
N19808385: length 3.9
  TOP w0.254: R490.2 R489.2 138.55,55.2 v1(138.55,55.4) QN22.3
N19808449: length 4.1
  TOP w0.102: v1(139.75,56.82) 139.75,56.62 QN22.1
  TOP w0.254: QN22.1 141.8,55.82 C521.1 141.71,55.66 R491.1
N19808451: length 3.4
  TOP w0.102: QN21.1 v1(140.55,60.15)
  TOP w0.203: R456.1 C509.1 141.67,59.25 QN21.1
N19808578: length 6.1
  TOP w0.254: QN24.3 136.39,45.99 v1(136.93,46.53) 137.39,46.99 137.39,48.64 136.88,49.15 R520.2 R521.2
N19808587: length 11.6
  TOP w0.203: R456.2 142.82,54.48 R491.2
  TOP w0.254: R491.2 141.71,53.09 141.02,52.4 138.13,52.4 v2(137.52,51.79) 136.88,51.16 R520.1
N19808632: length 8.3
  TOP w0.102: Q29.G 134.19,52.96 v1(134.19,52.5)
  TOP w0.254: Q29.G 135.72,52.78 137.69,52.78 C528.2 138.82,52.83 140.18,52.83 140.56,53.21 R490.1
N19957125: length 2.6
  TOP w0.102: v1(6.45,118.44) Q18.B 7.55,118.45 R340.2
N19957178: length 2.8
  TOP w0.102: R319.2 8.66,125.73 Q14.B v1(6.4,125.73)
N19957214: length 2.6
  TOP w0.102: v1(6.45,122.1) Q17.B 9.01,122.1 R328.2
N19957293: length 5
  TOP w0.102: Q13.C v1(6.41,129.25) 7.06,128.6 8.05,128.6 8.99,127.66 R314.1
N19957299: length 1.8
  TOP w0.102: R309.2 8.22,129.38 Q13.B
N19957316: length 3.9
  TOP w0.102: v1(6.48,133.14) 6.5,133.16 QN16.1 8.73,133.16 C346.2 R305.2
N19987352: length 5.7
  TOP w0.102: QN27.3 130.74,27.34 R691.1 132.36,27.34 QN28.1 v1(134.37,27.03)
N19987362: length 5.6
  TOP w0.102: QN29.3 141.33,28.35 R669.1 143.8,28.1 v1(143.8,27.28) QN30.1
N19989670: length 10
  TOP w0.102: QN37.1 52.49,17.34 C624.2 53.44,18.14 53.57,18.26 53.57,20.55 52.78,21.34 51.56,21.34 v2(50.98,21.92) 50.55,22.35 50.55,23.14 50.22,23.46 R725.2
N19989709: length 9
  TOP w0.102: R743.2 50.02,14.32 v1(49.86,14.48) 50.31,14.93 QN37.3 51.13,15.95 51.31,16.13 51.31,17.45 52.04,18.19 53.11,18.19 53.34,18.41 53.34,19.23 53.19,19.38 U41.2
N19989711: length 4.2
  TOP w0.102: R714.1 R713.1 47.47,24.41 v1(47.7,24.18) 47.7,23.49 R723.2 47.92,23.46 R724.2
N19992201: length 4.2
  TOP w0.102: R347.2 194,113.6 C381.2 193.52,113.6 QN18.1 v1(192.11,112.39)
N19992217: length 3.7
  TOP w0.102: QN18.3 190.11,113.9 v1(189.81,113.6) QN17.1 188.55,112.61 R348.2
N19992251: length 11.3
  TOP w0.102: R335.1 186.44,120.19 187.15,119.48 v1(187.15,115.67) 187.15,115.15 QN17.3 185.11,114.55 R346.1 R345.2 183.62,115.29 183.26,115.65 U29.2
N19992378: length 4.2
  TOP w0.102: R333.2 184.39,121.48 R334.2 185.34,119.87 Q20.B v1(186.07,118.16)
N19992399: length 2.1
  TOP w0.102: R335.2 C364.2 R336.1
