# Allegro board ECS H11H4-AD2 v1.1 boardview.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
PEG_TX_P4: length 87.4
  TOP w0.089: CPU1.E1 104.21,162.43 103.87,162.43 103.74,162.56 101.94,162.56 101.93,162.55 101.91,162.55
  TOP w0.102: v1(93.37,163.83) 93.73,163.47 93.73,162.86 94.03,162.55 101.91,162.55 ; C262.1 23.79,166.21 27.63,166.21 28.52,167.11 58.39,167.11 58.61,166.89 58.61,166.65 v1(58.29,166.34)
  BOTTOM w0.102: v1(58.29,166.34) 58.65,165.98 58.65,165.6 58.92,165.33 70.56,165.33 72.26,167.03 90.28,167.03 92.79,164.53 93.45,164.53 93.73,164.25 93.73,163.96 93.6,163.83 v1(93.37,163.83)
PEG_TX_P5: length 91.6
  TOP w0.089: CPU1.F2 105.61,161.29 105.71,161.39 105.71,161.54 105.59,161.67 104.09,161.67 103.91,161.85 102.27,161.85 102.26,161.84 102.24,161.84
  TOP w0.102: v1(90.73,162.94) 91.08,162.58 91.08,162.32 91.57,161.84 102.24,161.84 ; v1(53.14,164.99) 53.49,165.35 53.49,165.51 53.26,165.74 30.84,165.74 27.3,162.2 25.14,162.2 23.84,162.2 C270.1
  BOTTOM w0.102: v1(53.14,164.99) 53.49,164.63 53.49,163.17 54.03,162.64 58.17,162.64 59.34,163.8 70.92,163.8 72.86,165.74 88.93,165.74 91.08,163.58 91.08,163.3 v1(90.73,162.94)
PEG_TX_P6: length 91.2
  TOP w0.089: CPU1.G1 104.67,160.38 104.79,160.49 104.79,160.64 104.7,160.73 104.17,160.73 104.05,160.62 103.42,160.62 102.97,161.07 97.41,161.07 97.41,161.06 97.38,161.06
  TOP w0.102: 97.38,161.06 88.87,161.06 88.65,161.28 88.65,161.57 v1(88.29,161.93) ; v1(63.55,162.24) 63.91,162.59 63.91,163.22 62.74,164.39 59.26,164.39 58.01,163.14 30.6,163.14 26.09,158.64 24.05,158.64 23.81,158.39 23.81,158.07 C275.1
  BOTTOM w0.102: v1(63.55,162.24) 63.91,161.88 63.91,161.52 64.24,161.19 70.26,161.19 73.53,164.47 86.78,164.47 88.62,162.63 88.62,162.26 v1(88.29,161.93)
PEG_TX_P7: length 91.4
  TOP w0.089: 97.38,160.45 97.41,160.45 97.41,160.46 102.74,160.46 103.17,160.02 103.96,160.02 104.14,159.84 105.56,159.84 105.71,159.69 105.71,159.56 105.61,159.46 CPU1.H2
  TOP w0.102: v1(85.37,161.54) 85.72,161.19 85.72,160.78 86.06,160.45 97.38,160.45 ; C279.1 23.93,154.61 30.97,161.64 58.91,161.64 59.21,161.34 59.21,161.14 v1(58.88,160.8)
  BOTTOM w0.102: v1(58.88,160.8) 59.23,160.45 59.23,160.04 59.45,159.82 70.77,159.82 74.13,163.17 84.71,163.17 85.72,162.16 85.72,161.9 v1(85.37,161.54)
PEG_TX_P8: length 91.6
  TOP w0.089: CPU1.J1 104.71,158.55 104.79,158.63 104.79,158.77 104.66,158.9 103.3,158.9 102.45,159.75 97.41,159.75 97.41,159.75 97.38,159.75
  TOP w0.102: v1(82.93,160.76) 83.26,160.43 83.26,159.99 83.51,159.75 97.38,159.75 ; v1(53.12,159.59) 53.12,159.59 53.47,159.94 53.47,160.12 53.24,160.35 33.54,160.35 23.81,150.62 C297.1
  BOTTOM w0.102: v1(82.93,160.76) 83.26,161.09 83.26,161.26 82.62,161.9 74.63,161.9 71.3,158.57 53.7,158.57 53.47,158.79 53.47,159.24 v1(53.12,159.59)
PEG_TX_P9: length 93.5
  TOP w0.089: CPU1.K2 105.64,157.63 105.74,157.74 105.74,157.87 105.64,157.98 104.13,157.98 103.76,158.34 102.91,158.34 102.14,159.11 97.41,159.11 97.41,159.1 97.38,159.1
  TOP w0.102: v1(53.11,156.8) 53.47,157.16 53.47,157.3 53.21,157.56 34.12,157.56 23.93,147.37 C316.1 ; 97.38,159.1 81.01,159.1 80.59,159.51 80.59,159.96 80.41,160.15 v1(80.26,160.15)
  BOTTOM w0.102: v1(80.26,160.15) 80.54,160.43 80.54,160.55 80.42,160.68 75.23,160.68 71.45,156.9 59.03,156.9 57.45,155.32 54.13,155.32 53.47,155.98 53.47,156.45 v1(53.11,156.8)
PEG_TX_P10: length 94.5
  TOP w0.089: 97.38,158.45 97.41,158.45 97.41,158.46 101.87,158.46 102.4,157.92 103.4,156.92 104.01,156.92 104.19,157.1 104.66,157.1 104.79,156.97 104.79,156.83 104.68,156.72 CPU1.L1
  TOP w0.102: 97.38,158.45 80.73,158.45 79.81,157.53 78.79,157.53 78.47,157.85 78.47,158.18 v1(78.16,158.5) ; C333.1 23.93,142.96 36.07,155.09 56.18,155.09 56.51,154.76 56.51,154.58 v1(56.17,154.23)
  BOTTOM w0.102: v1(78.16,158.5) 78.44,158.78 78.44,159.3 78.35,159.38 75.75,159.38 71.97,155.6 63.36,155.6 62.11,154.36 58.86,154.36 57.74,153.24 56.85,153.24 56.54,153.54 56.54,153.85 v1(56.17,154.23)
PEG_TX_P11: length 95.4
  TOP w0.089: CPU1.M2 105.62,155.8 105.7,155.88 105.7,156.04 105.59,156.16 104.06,156.16 103.79,156.44 102.99,156.44 101.64,157.78 101.44,157.78
  TOP w0.102: v1(76.78,156.53) 77.14,156.88 80.05,156.88 80.95,157.78 101.44,157.78 ; v1(53.09,152.58) 53.47,152.95 53.47,153.11 53.19,153.39 38.08,153.39 23.93,139.24 C335.1
  BOTTOM w0.102: v1(76.78,156.53) 76.45,156.86 75.71,156.86 73.01,154.15 63.74,154.15 61.27,151.69 59.36,151.69 58.42,152.63 55.78,152.63 54.43,151.28 53.84,151.28 53.45,151.67 53.45,152.22 v1(53.09,152.58)
PEG_TX_P12: length 96
  TOP w0.089: CPU1.N1 104.69,154.89 104.79,154.99 104.79,155.12 104.63,155.27 104.24,155.27 104.01,155.04 102.91,155.04 100.82,157.13 97.41,157.13 97.4,157.12 97.38,157.12
  TOP w0.102: v1(53.14,150.25) 53.47,150.58 53.47,150.83 53.26,151.03 48.6,151.03 35.46,137.89 26.75,137.89 23.81,134.94 C343.1 ; v1(78.68,155.31) 79,155.63 79.88,155.63 81.38,157.12 97.38,157.12
  BOTTOM w0.102: v1(78.68,155.31) 78.36,155.63 78.14,155.63 75.27,152.76 64.24,152.76 61.87,150.39 57.4,150.39 55.68,148.67 53.85,148.67 53.49,149.02 53.49,149.89 v1(53.14,150.25)
PEG_TX_P13: length 97.4
  TOP w0.089: CPU1.P2 105.64,153.97 105.69,154.03 105.69,154.2 105.54,154.36 103.91,154.36 103.76,154.51 101.84,154.51 101.84,154.51 101.76,154.51 101.68,154.51 101.64,154.55 101.63,154.55 101.62,154.56
  TOP w0.102: 101.62,154.56 101.25,154.92 99.92,156.26 83.7,156.26 83.17,155.73 82.39,155.73 82.11,156.01 81.91,156.01 v1(81.65,155.74) ; C348.1 23.85,130.47 23.85,130.99 29.41,136.55 36.55,136.55 48.69,148.69 55.7,148.69 56.41,149.4 56.79,149.4 57.02,149.17 57.02,148.96 v1(56.69,148.63)
  BOTTOM w0.102: v1(56.69,148.63) 57.05,148.28 57.05,147.98 57.38,147.65 61.06,147.65 64.92,151.51 77.04,151.51 80.9,155.37 80.9,155.8 81.08,155.98 81.4,155.98 v1(81.65,155.74)
PEG_TX_P14: length 100.7
  TOP w0.089: v5(102.92,153.92) 102.68,153.68 102.68,153.38 102.78,153.28 103.48,153.28 103.62,153.42 104.7,153.42 105.05,153.06 CPU1.R2
  TOP w0.102: v1(53.7,145.72) 54.03,146.05 54.03,146.3 53.9,146.43 48.49,146.43 37.11,135.05 30.75,135.05 23.98,128.28 23.98,127.23 23.78,127.03 23.78,126.6 C354.1
  BOTTOM w0.102: v5(102.92,153.92) 102.64,153.64 102.64,153.37 102.44,153.16 101.74,153.16 98.67,156.24 84.44,156.24 77.4,149.2 64.47,149.2 61.65,146.38 56.07,146.38 55.65,145.97 55.65,145.25 55.1,144.7 54.32,144.7 54.05,144.98 54.05,145.37 v1(53.7,145.72)
PEG_TX_P15: length 101.8
  TOP w0.089: 102.07,152.57 102.12,152.52 105.59,152.52 105.71,152.39 105.71,152.22 105.64,152.15 CPU1.T2
  TOP w0.102: 102.07,152.57 100.29,154.36 93.9,154.36 v5(93.58,154.04) ; C357.1 23.1,123.22 23.66,123.22 23.77,123.32 23.77,124.35 33.17,133.76 38.07,133.76 49.12,144.81 52.1,144.81 52.65,144.25 53.16,144.25 54.53,142.88 55.58,142.88 55.75,143.05 55.75,143.28 v1(55.4,143.63)
  BOTTOM w0.102: v5(93.58,154.04) 93.31,154.31 92.94,154.31 92.23,155.02 84.96,155.02 77.21,147.27 64.4,147.27 61.81,144.68 59.61,144.68 57.61,142.67 56.01,142.67 55.75,142.93 55.75,143.28 v1(55.4,143.63)
PEX1_100M_N: length 169
  TOP w0.102: v3(52.75,62.92) 52.75,63.01 52.45,63.3 PCH1.D5 ; v1(43.59,183.77) 43.87,183.77 44.02,183.92 44.02,184.28 43.79,184.51 43.38,184.51 43.1,184.22 40.31,184.22 40.23,184.14 40.2,184.08 40.31,183.74 PCIE1X.A14
  BOTTOM w0.089: v3(52.75,62.92) 52.75,62.9 53.01,62.64 53.22,62.64 53.44,62.86 53.44,63.65 53.09,64.01 52.35,64.01 51.77,63.42 51.03,63.42 50.69,63.09 50.69,62.95 50.69,62.79 50.65,62.75 50.65,62.74 50.64,62.73
  BOTTOM w0.102: v1(43.59,183.77) 43.81,183.77 44.02,183.57 44.02,183.18 42.93,182.09 42.93,178.66 40.77,176.5 40.77,116.56 33.65,109.45 33.65,88.95 27.18,82.47 27.18,72.32 27.48,72.02 27.48,59.41 28.3,58.6 37.01,58.6 39.76,61.34 49.25,61.34 50.64,62.73
PEX1_100M_P: length 169
  TOP w0.102: v1(44.5,183.77) 44.22,184.05 44.22,184.36 43.87,184.71 43.3,184.71 43.02,184.43 40.23,184.43 40.06,184.26 40.03,184.21 40.01,184.17 39.67,184.05 PCIE1X.A13 ; PCH1.E6 52.98,62.44 v3(53.32,62.1)
  BOTTOM w0.089: v3(53.32,62.1) 53.32,62.47 53.63,62.78 53.63,63.73 53.16,64.2 52.27,64.2 51.69,63.61 50.95,63.61 50.5,63.17 50.5,62.88 50.5,62.87
  BOTTOM w0.102: 50.5,62.87 49.17,61.54 39.67,61.54 36.93,58.8 28.38,58.8 27.69,59.49 27.69,72.1 27.38,72.41 27.38,82.39 33.86,88.87 33.86,109.36 40.97,116.48 40.97,176.42 43.13,178.58 43.13,182.01 44.22,183.1 44.22,183.49 v1(44.5,183.77)
PEX1_RST_L2: length 6.6
  TOP w0.102: R246.1 43.47,186.79 C229.1 41.88,185.83 41.4,186.31 40.28,186.31 38.99,187.61 PCIE1X.A11
PEX1_RX_N5: length 161.4
  TOP w0.102: v3(59.34,60.12) 59.69,60.12 59.8,60.23 PCH1.K19 ; v1(45.18,179.12) 44.82,179.48 42.82,179.48 41.96,180.34 40.41,180.34 40.06,180.69 39.58,180.69 PCIE1X.A17
  BOTTOM w0.102: v3(59.34,60.12) 58.96,59.74 56.63,59.74 55.24,61.12 55.24,67.28 53.54,68.99 49.85,68.99 47.74,66.88 44.5,66.88 39.9,71.48 33.15,71.48 28.85,75.77 28.85,82.78 34.54,88.47 34.54,109.06 41.66,116.17 41.66,175.94 43.92,178.2 43.92,179.16 44.25,179.5 44.8,179.5 v1(45.18,179.12)
PEX1_RX_N7: length 89.3
  TOP w0.089: PCH1.L22 61.06,59.61 61.54,59.14 v3(61.54,59.03)
  TOP w0.102: v1(85.75,14.27) 86.11,13.92 86.11,13.61 88.21,11.51 88.8,11.51 v2(89.13,11.18) 89.46,11.51 91.74,11.51 92.53,10.72 94.98,10.72 95.59,11.33 96.19,11.33 96.29,11.23 96.29,11.04 R753.2
  BOTTOM w0.089: v3(61.54,59.03) 61.54,59.1 61.75,59.31 61.96,59.31 62.13,59.14 62.13,58.6 62.61,58.12 63.54,58.12 63.92,58.5 66.67,58.5 68.35,60.17 68.93,60.17 68.94,60.17 68.96,60.17
  BOTTOM w0.102: v1(85.75,14.27) 86.13,14.66 86.13,17 87.3,18.17 87.3,30.12 86.54,30.88 86.54,37.36 88.77,39.6 88.77,44.96 87.25,46.48 87.25,57.43 86.49,58.19 85.64,58.19 82.62,61.21 74.12,61.21 73.07,60.17 68.96,60.17
PEX1_RX_N7_S: length 3.2
  TOP w0.102: M2_2.29 98.59,11.92 98.48,12.04 97.97,12.04 97.82,11.89 97.82,11.71 97.46,11.35 97.31,11.35 97.03,11.07 97.03,10.92 R753.1
PEX1_RX_N8: length 119.1
  TOP w0.102: v1(77.67,72.14) 78,72.47 78,73.05 77.42,73.63 65.81,73.63 63.98,71.81 62.72,71.81 v1(62.37,71.46) ; v1(94.34,12.29) 94.46,12.29 94.67,12.09 94.67,11.84 94.45,11.63 93,11.63 92.71,11.92 92.71,12.24 93.07,12.6 R747.2 ; v3(62.76,60.02) 62.59,60.02 PCH1.K24
  BOTTOM w0.089: v3(62.76,60.02) 62.76,59.8 62.9,59.65 63.04,59.65 63.17,59.78 63.17,60.58 63.48,60.9 63.95,60.9 64.34,61.28 65.47,61.28 66.29,62.1 66.29,62.26 66.28,62.26 66.28,62.28
  BOTTOM w0.102: 66.28,62.28 66.28,63.36 65.51,64.13 65.51,65.89 64.29,67.11 64.29,69.01 62.97,70.33 62.97,71.72 62.87,71.81 62.73,71.81 v1(62.37,71.46) ; v1(77.67,72.14) 78.03,72.5 78.03,73.08 79.17,74.22 85.65,74.22 87.25,72.62 87.25,71.64 88.52,70.37 88.52,69.1 91.16,66.45 91.16,63.22 92.66,61.72 92.66,44.51 93.17,44 93.17,38.32 92.38,37.53 92.38,32.93 92.96,32.34 92.96,30.02 95.68,27.31 95.68,25.64 96.55,24.77 96.55,11.86 96.01,11.33 95.02,11.33 94.74,11.61 94.74,12.09 94.54,12.29 v1(94.34,12.29)
PEX1_RX_P5: length 161.4
  TOP w0.102: PCIE1X.A16 40.76,181.4 40.31,180.95 40.31,180.73 40.5,180.54 42.05,180.54 42.91,179.68 44.82,179.68 v1(45.18,180.04) ; PCH1.L19 59.44,59.61 v3(59.26,59.43)
  BOTTOM w0.102: v1(45.18,180.04) 44.85,179.7 44.17,179.7 43.71,179.25 43.71,178.28 41.45,176.02 41.45,116.26 34.34,109.14 34.34,88.55 28.65,82.86 28.65,75.68 33.06,71.27 39.82,71.27 44.42,66.68 47.83,66.68 49.94,68.78 53.46,68.78 55.04,67.2 55.04,61.04 56.54,59.53 59.16,59.53 v3(59.26,59.43)
PEX1_RX_P7: length 89.3
  TOP w0.089: PCH1.K22 60.9,60.05 61.26,59.69 v3(61.62,59.69)
  TOP w0.102: v1(86.66,14.27) 86.31,13.92 86.31,13.7 87.21,12.8 v2(87.68,12.8) 87.68,12.33 88.3,11.71 91.83,11.71 92.62,10.92 94.89,10.92 95.5,11.53 95.96,11.53 96.19,11.76 96.19,11.94 R752.2
  BOTTOM w0.089: 68.96,60.37 68.94,60.37 68.94,60.36 68.27,60.36 66.6,58.69 63.84,58.69 63.46,58.31 62.69,58.31 62.32,58.68 62.32,59.22 62.03,59.51 61.8,59.51 v3(61.62,59.69)
  BOTTOM w0.102: v1(86.66,14.27) 86.51,14.27 86.33,14.45 86.33,16.92 87.5,18.08 87.5,30.2 86.74,30.96 86.74,37.28 88.98,39.51 88.98,45.04 87.45,46.57 87.45,57.51 86.57,58.39 85.72,58.39 82.7,61.42 74.03,61.42 72.99,60.37 68.96,60.37
PEX1_RX_P7_S: length 3.2
  TOP w0.102: M2_2.31 98.61,12.42 98.42,12.24 97.88,12.24 97.61,11.97 97.61,11.79 97.38,11.56 97.21,11.56 97.07,11.69 R752.1
PEX1_RX_P8: length 119.1
  TOP w0.102: v1(95.25,12.29) 94.87,11.91 94.87,11.76 94.54,11.43 92.91,11.43 92.51,11.84 92.51,12.24 92.14,12.6 R746.1 ; PCH1.L24 62.59,59.25 v3(62.76,59.25) ; v1(78.59,72.14) 78.43,72.14 78.21,72.36 78.21,73.13 77.5,73.84 65.73,73.84 63.9,72.01 62.74,72.01 v1(62.37,72.37)
  BOTTOM w0.089: 66.48,62.28 66.48,62.02 65.55,61.09 64.41,61.09 64.03,60.71 63.56,60.71 63.36,60.5 63.36,59.7 63.12,59.46 62.96,59.46 v3(62.76,59.25)
  BOTTOM w0.102: 66.48,62.28 66.48,63.44 65.71,64.22 65.71,65.97 64.49,67.19 64.49,69.1 63.17,70.42 63.17,71.81 62.96,72.02 62.73,72.02 v1(62.37,72.37) ; v1(78.59,72.14) 78.23,72.5 78.23,72.99 79.26,74.02 85.56,74.02 87.05,72.53 87.05,71.55 88.32,70.28 88.32,69.01 90.96,66.37 90.96,63.14 92.46,61.64 92.46,44.42 92.96,43.92 92.96,38.4 92.18,37.62 92.18,32.84 92.76,32.26 92.76,29.94 95.48,27.22 95.48,25.55 96.34,24.69 96.34,11.95 95.93,11.53 95.11,11.53 94.95,11.69 94.95,11.99 v1(95.25,12.29)
PEX1_TX_N5: length 154.5
  TOP w0.089: 60.45,65.07 60.46,65.07 60.75,64.79 60.75,63.92 60.86,63.81 60.86,63.45 61.06,63.25 PCH1.D22
  TOP w0.102: v3(59.16,65.81) 59.31,65.96 59.53,65.96 60.42,65.07 60.45,65.07 ; v1(45.34,181.37) 45.01,181.7 44.86,181.7 C238.1
  BOTTOM w0.102: v1(45.34,181.37) 45.68,181.71 45.87,181.71 46.18,181.41 46.18,174.23 42.14,170.19 42.14,115.95 35.05,108.86 35.05,88.21 29.36,82.52 29.36,75.96 33.37,71.96 40.12,71.96 44.67,67.41 47.59,67.41 49.7,69.52 53.87,69.52 57.32,66.07 58.9,66.07 v3(59.16,65.81)
PEX1_TX_N7: length 107.2
  TOP w0.089: 61.65,66.19 61.65,66.18 62,65.83 62,64.31 61.9,64.21 61.9,63.68 PCH1.C23
  TOP w0.102: 61.65,66.19 61.65,67.56 59.51,69.7 59.51,72.44 61.7,74.63 64.77,74.63 65.15,75.01 80.47,75.01 81.89,73.58 81.89,72.82 v1(81.61,72.54) ; C633.2 96.12,13.48 95.96,13.64 95.65,13.64 95.22,14.07 95,14.07 94.78,13.86 v1(94.78,13.74)
  BOTTOM w0.102: v1(81.61,72.54) 81.94,72.87 81.94,73.16 82.29,73.51 85.27,73.51 86.52,72.26 86.52,71.35 87.83,70.04 87.83,68.79 90.47,66.15 90.47,62.87 91.95,61.39 91.95,44.1 92.48,43.57 92.48,38.78 91.62,37.91 91.62,32.67 92.23,32.06 92.23,29.67 94.77,27.13 94.77,25.51 95.86,24.42 95.86,14.53 95.45,14.12 95.16,14.12 v1(94.78,13.74)
PEX1_TX_N7_S: length 2.7
  TOP w0.102: M2_2.35 98.64,13.42 98.48,13.59 97.43,13.59 97.07,13.23 C633.1
PEX1_TX_N8: length 106.5
  TOP w0.089: 62.52,66.72 62.52,66.7 62.51,66.69 62.51,64.18 62.41,64.08 62.41,63.96 62.18,63.73 PCH1.C24
  TOP w0.102: 62.52,66.72 62.52,67.82 60.22,70.11 60.22,72.16 61.95,73.89 65.05,73.89 65.48,74.32 78.99,74.32 80.24,73.08 80.24,72.31 80.09,72.16 79.92,72.16 v1(79.86,72.22)
  BOTTOM w0.102: SC68.1 90.86,14.17 90.55,14.17 90.45,14.07 90.45,13.52 90.69,13.28 93.29,13.28 93.85,13.85 93.85,16.03 94.92,17.09 94.92,23.83 93.55,25.2 93.55,26.57 91.29,28.83 91.29,31.72 90.7,32.31 90.7,38.35 91.06,38.71 91.06,60.98 89.59,62.45 89.59,65.78 86.94,68.42 86.94,69.62 85.5,71.07 85.5,71.58 85.14,71.93 84.34,71.93 83.37,70.97 80.82,70.97 80.37,71.42 80.37,71.94 80.09,72.22 v1(79.86,72.22)
PEX1_TX_P5: length 154.4
  TOP w0.089: 60.51,65.27 60.53,65.27 60.94,64.87 60.94,64 61.05,63.89 61.05,63.69 PCH1.C22
  TOP w0.102: v1(45.34,182.28) 44.96,181.9 44.86,181.9 C236.1 ; 60.51,65.27 59.61,66.17 v3(59.16,66.62)
  BOTTOM w0.102: v1(45.34,182.28) 45.71,181.91 45.96,181.91 46.38,181.49 46.38,174.14 42.34,170.1 42.34,115.87 35.26,108.78 35.26,88.13 29.57,82.44 29.57,76.05 33.45,72.16 40.21,72.16 44.75,67.61 47.51,67.61 49.62,69.72 53.95,69.72 57.4,66.27 58.8,66.27 v3(59.16,66.62)
PEX1_TX_P7: length 107.1
  TOP w0.089: PCH1.B23 61.71,64 61.71,64.29 61.81,64.39 61.81,65.75 61.45,66.11
  TOP w0.102: 61.45,66.11 61.45,67.48 59.31,69.61 59.31,72.53 61.61,74.83 64.69,74.83 65.07,75.21 80.55,75.21 82.09,73.67 82.09,72.67 82.3,72.47 82.45,72.47 v1(82.52,72.54) ; C632.2 96.24,14.3 96.34,14.2 96.34,13.91 96.28,13.84 95.73,13.84 95.3,14.27 95,14.27 94.78,14.49 v1(94.78,14.66)
  BOTTOM w0.102: v1(94.78,14.66) 95.11,14.33 95.37,14.33 95.66,14.61 95.66,24.33 94.56,25.43 94.56,27.04 92.02,29.58 92.02,31.98 91.41,32.59 91.41,38 92.28,38.86 92.28,43.48 91.74,44.02 91.74,61.31 90.27,62.78 90.27,66.07 87.63,68.71 87.63,69.95 86.31,71.27 86.31,72.17 85.18,73.3 82.37,73.3 82.14,73.08 82.14,72.72 82.32,72.54 v1(82.52,72.54)
PEX1_TX_P7_S: length 2.7
  TOP w0.102: M2_2.37 98.63,13.92 98.5,13.79 97.58,13.79 C632.1
PEX1_TX_P8: length 106.5
  TOP w0.089: PCH1.B24 62.32,64.26 62.32,66.69 62.31,66.7 62.31,66.72
  TOP w0.102: v1(80.77,72.22) 80.76,72.22 80.44,72.54 80.44,73.16 79.08,74.52 65.4,74.52 64.97,74.09 61.87,74.09 60.02,72.25 60.02,70.03 62.31,67.74 62.31,66.72
  BOTTOM w0.102: SC67.1 90.09,14.08 90.25,13.92 90.25,13.44 90.6,13.08 93.37,13.08 94.06,13.77 94.06,15.94 95.12,17.01 95.12,23.91 93.75,25.28 93.75,26.65 91.49,28.91 91.49,31.81 90.91,32.39 90.91,38.27 91.26,38.63 91.26,61.06 89.79,62.53 89.79,65.86 87.15,68.5 87.15,69.71 85.7,71.15 85.7,71.66 85.23,72.14 84.25,72.14 83.29,71.17 80.91,71.17 80.57,71.51 80.57,72.02 v1(80.77,72.22)
PEX16_100M_N: length 189
  TOP w0.102: v1(34.65,176.11) 34.37,175.83 34.37,175.36 34.09,175.08 32.03,175.08 22.89,184.22 20,184.22 19.91,184.14 19.88,184.08 20,183.74 PCIE16X.A14 ; PCH1.W10 54.92,55.59 v3(55.27,55.95)
  BOTTOM w0.102: v3(55.27,55.95) 55.47,56.15 55.47,56.41 55.37,56.51 53.41,56.51 52.09,57.84 41.16,57.84 40.41,57.09 40.41,56.22 37.64,53.44 27.14,53.44 25.43,55.16 25.43,71.17 25.12,71.47 25.12,83.69 29.97,88.54 29.97,107.75 39.4,117.17 39.4,136.93 31.98,144.35 31.98,175.95 33.19,177.17 34.02,177.17 34.32,176.87 34.32,176.44 v1(34.65,176.11)
PEX16_100M_P: length 189
  TOP w0.102: PCH1.W11 55.68,55.8 55.83,55.95 v3(56.04,55.95) ; v1(33.73,176.11) 34,176.11 34.16,175.95 34.16,175.45 34,175.29 32.11,175.29 22.97,184.43 19.92,184.43 19.75,184.26 19.7,184.17 19.36,184.05 PCIE16X.A13
  BOTTOM w0.102: v3(56.04,55.95) 55.81,55.95 55.68,56.08 55.68,56.5 55.46,56.72 53.49,56.72 52.17,58.04 41.07,58.04 40.21,57.18 40.21,56.3 37.55,53.64 27.23,53.64 25.63,55.25 25.63,71.25 25.32,71.56 25.32,83.61 30.18,88.46 30.18,107.66 39.6,117.09 39.6,137.02 32.18,144.43 32.18,175.87 33.27,176.96 33.93,176.96 34.11,176.78 34.11,176.23 33.99,176.11 v1(33.73,176.11)
PEX16_RST: length 10.4
  TOP w0.102: R248.1 v1(24.18,185.58) 26.1,185.58 26.52,185.17 26.52,184.37 R253.1 26.27,184.11 U23.4 28.26,184.11 28.8,184.66 30.84,184.66 31.38,184.12 R254.1
PEX16_RST_L: length 5.4
  TOP w0.102: PCIE16X.A11 20.54,186.53 C230.1 R248.2
PHASE1_A: length 56.3
  TOP w0.203: U19.26 162.16,214.11 v1(162.03,214.25) ; L13.1 125.83,191.93 SP1.1
  TOP w0.508: C104.2 158.82,214.37 159.72,215.27 161.14,215.27 162.03,214.38 v1(162.03,214.25) ; R222.1 v1(124.69,196.85)
  BOTTOM w0.508: v1(162.03,214.25) 162.03,213.49 161.49,212.95 159.21,212.95 157.71,211.46 150.85,211.46 146.61,207.21 144.53,207.21 141.79,204.47 130.73,204.47 129.72,203.46 129.72,197.69 128.12,196.09 125.32,196.09
  vias: v1(118.47,191.52) v1(118.47,188.98) v1(119.74,191.52) v1(120.37,188.98) v1(120.62,197.23) v1(121.51,195.58) v1(121.51,194.31) v1(121.51,192.15) v1(121.77,198.37) v1(122.53,197.1) v1(123.42,193.17) v1(123.55,197.1) v1(123.93,191.39) v1(124.94,194.44) v1(126.72,192.91)
PHASE1_B: length 100.6
  TOP w0.203: SP8.1 180.99,151.76 L17.1 ; v1(159.87,209.3) 160.45,209.88 161.01,209.88 161.53,210.4 U19.35
  TOP w0.508: v1(153.9,194.18) 154.1,193.98 175.29,193.98 175.95,193.32 v1(175.95,192.89) ; C137.2 159.74,209.17 v1(159.87,209.3) ; R290.1 v1(185.42,153.21)
  BOTTOM w0.508: v1(175.95,192.89) 175.95,186.74 176.52,186.17 190.33,186.17 193.67,182.82 193.67,173.81 192.3,172.44 192.3,166.8 185.9,160.4 ; v1(159.87,209.3) 159.87,209.14 156.15,205.42 156.15,204.26 151.74,199.85 151.74,195.83 153.39,194.18 v1(153.9,194.18)
  vias: v1(178.03,158.88) v1(178.03,156.72) v1(179.04,155.96) v1(180.57,158.88) v1(180.57,157.61) v1(180.82,149.73) v1(181.84,154.31) v1(181.84,151) v1(182.47,149.73) v1(182.73,155.83) v1(183.49,152.65) v1(184,155.83) v1(184.38,149.73) v1(185.39,154.81) v1(186.41,155.83)
PHASE1A_R: length 95.9
  TOP w0.203: v1(129.32,190.31) 129.01,189.99 126.15,189.99 SP1.2 ; R73.2 R72.2 174.6,221.71 174.09,222.22 v1(174.09,222.76)
  BOTTOM w0.203: v1(174.09,222.76) 173.85,222.52 173.85,222.16 173.43,221.74 171.44,221.74 170.71,221.01 170.71,218.97 171.6,218.08 175.03,218.08 176.28,216.84 176.28,214.41 175.2,213.33 173.4,213.33 171.58,211.52 170.25,210.19 169.51,210.19 167.55,208.23 166.15,208.23 161.16,203.24 161.16,202.82 158.72,200.38 158.72,195.33 153.01,189.61 145.77,189.61 144.75,188.59 142.94,188.59 140.72,186.37 140.72,182.91 139.8,181.99 130.4,181.99 128.98,183.41 128.98,187.35 128.12,188.21 128.12,189.48 128.63,189.99 129.01,189.99 v1(129.32,190.31)
PHASE1B_R: length 72.6
  TOP w0.203: R208.2 170.23,201.06 v1(170.23,201.5) 170.23,202.04 R188.2 ; SP8.2 179.04,152.08 179.04,152.78 176.5,155.32 170.51,155.32 170.18,155.65 170.18,156.36 v1(170.43,156.62)
  BOTTOM w0.203: v1(170.23,201.5) 170.08,201.35 170.08,200.23 v2(170.36,199.95) 170.08,199.67 170.08,196.93 168.68,195.53 168.68,180.29 170.43,178.54 170.43,173.14 171.39,172.18 176.07,172.18 177.85,170.4 177.85,167.6 176.95,166.7 171.93,166.7 170.23,165 170.23,156.82 v1(170.43,156.62)
PHASE2_A: length 33.8
  TOP w0.203: SP2.1 143.36,191.93 L14.1 ; U19.30 161.08,212.4 160.86,212.62 160.15,212.62 v1(159.66,212.14)
  TOP w0.508: C125.2 159.61,212.09 v1(159.66,212.14) ; R223.1 v1(140.44,196.85)
  BOTTOM w0.508: 139.93,197.87 139.93,199.74 145.37,205.18 147.52,205.18 151.46,209.12 157.2,209.12 159.66,211.58 v1(159.66,212.14)
  vias: v1(134.09,197.99) v1(135.99,197.99) v1(136.12,191.52) v1(136.12,188.98) v1(137.64,197.99) v1(137.77,191.52) v1(137.77,188.98) v1(139.55,196.09) v1(139.55,194.82) v1(139.55,192.66) v1(141.2,193.93) v1(141.33,191.64) v1(142.47,194.44)
PHASE2_B: length 7
  TOP w0.203: SP10.1 180.99,134.37 L18.1
  TOP w0.254: C328.1 189.87,143.22 189.97,143.32 U27.8
  TOP w0.508: 186.66,142.49 187.55,142.49 188.28,143.22 C328.1 ; R303.1 185.42,135.51
  vias: v1(178.03,141.48) v1(178.03,140.34) v1(178.03,139.06) v1(180.57,141.48) v1(180.57,140.21) v1(181.84,136.91) v1(181.84,133.6) v1(182.85,138.3) v1(183.49,135.25) v1(184.12,138.3) v1(185.52,137.54) v1(185.52,136.4) v1(186.41,141.48) v1(187.17,141.48) v1(187.17,139.06)
PHASE2A_R: length 58.6
  TOP w0.203: v1(146.58,188.21) 146.33,188.47 146.33,188.87 145.2,189.99 143.68,189.99 SP2.2 ; R148.1 183.39,210.62 v1(183.39,210.11) 183.39,209.49 R164.2
  BOTTOM w0.203: v1(183.39,210.11) 183.31,210.11 183.16,210.26 183.16,210.77 182.73,211.2 179.62,211.2 179.27,211.55 179.27,211.55 178.73,212.09 176.19,212.09 176.04,212.24 173.35,212.24 170.58,209.47 169.82,209.47 167.87,207.52 166.45,207.52 161.87,202.95 161.87,202.53 159.49,200.14 159.49,195.01 151.93,187.45 146.51,187.45 146.33,187.63 146.33,187.96 v1(146.58,188.21)
PHASE2B_R: length 104
  TOP w0.203: R191.2 175.74,201.85 v1(175.49,201.6) R212.2 ; SP10.2 v1(179.36,133.29)
  BOTTOM w0.203: v1(179.36,133.29) 179.04,133.6 179.04,134.33 175.68,137.69 172.19,137.69 171.5,138.38 171.5,142.93 169.95,144.48 169.95,148.31 170.74,149.1 172.45,149.1 172.7,148.84 176.57,148.84 178.41,150.68 178.41,153.03 176.5,154.94 172.82,154.94 171.63,156.13 171.63,164.29 172.92,165.58 177.54,165.58 178.99,167.04 178.99,171.03 176.73,173.3 171.86,173.3 171.55,173.61 171.55,179 169.8,180.75 169.8,195.05 175.21,200.46 175.21,201.32 v1(175.49,201.6)
PHASE3_A: length 8.7
  TOP w0.203: SP6.1 180.99,169.8 L16.1
  TOP w0.254: C243.1 188.57,178.66 188.66,178.75 U24.8
  TOP w0.508: QCL5.D5 185.15,178.66 C243.1
  vias: v1(178.03,176.91) v1(178.03,174.75) v1(179.17,173.86) v1(180.44,176.91) v1(180.44,175.64) v1(180.7,173.74) v1(180.82,167.26) v1(181.84,172.34) v1(181.84,169.04) v1(181.84,166.24) v1(182.85,173.74) v1(183.36,171.07) v1(183.74,166.24) v1(184,173.74) v1(185.39,172.34) v1(185.39,171.07) v1(186.41,173.86)
PHASE3A_R: length 70.3
  TOP w0.203: R99.2 183.9,218.47 v1(183.72,218.29) 183.62,218.19 R115.2 ; v1(171.42,181.64) 171.17,181.89 170.76,181.89 170.59,181.72 170.59,180.42 171.42,179.58 171.42,174.01 172.21,173.23 176.73,173.23 179.04,170.92 179.04,170.12 SP6.2
  BOTTOM w0.203: v1(171.42,181.64) 171.2,181.86 170.86,181.86 170.51,182.21 170.51,194.76 176.78,201.02 176.78,203.51 179.49,206.22 184.21,206.22 186.41,208.42 186.41,216.98 185.09,218.3 183.73,218.3 v1(183.72,218.29)
PLTRST_R_N: length 8.1
  TOP w0.089: 63.73,36.96 63.73,37.34 63.88,37.49 ; 63.55,38.63 63.54,38.64 63.41,38.64 63.14,38.91 63.14,42.5 63.28,42.63 63.28,42.97 63.3,43 63.3,43.04 63.31,43.05 63.33,43.05 63.46,43.18 63.46,43.25 63.5,43.29 63.5,43.81 63.5,43.99 63.36,44.13 PCH1.BB27
  TOP w0.102: 63.88,37.49 63.88,38.3 63.55,38.63 ; 63.73,36.96 R609.1
PM_DOWN: length 241.1
  TOP w0.089: PCH1.AH2 46.78,51.06 45.64,52.2 45.06,52.2
  TOP w0.102: v1(12.93,52.1) 14.48,52.1 16.23,53.85 16.23,67 24.54,75.31 24.54,81.72 17.17,89.08 17.17,101.88 14.76,104.29 14.76,107.22 21.77,114.23 21.77,118.16 21.79,118.16 22.34,118.71 22.34,118.73 22.35,118.75 22.35,119.56 23.01,120.22 23.84,120.22 25.43,121.8 25.43,123.22 33.92,131.71 39.11,131.71 48.1,140.7 53.54,140.7 54.17,141.33 56.01,141.33 63.3,148.62 63.3,157.09 68.66,162.45 68.66,168.35 67.89,169.11 67.89,173.98 R273.1 ; 45.06,52.2 42.88,52.2 40.51,54.56 37.08,54.56 36.47,55.17 32.77,55.17 31.93,54.33 31.93,53.69 27.33,49.09 27.33,41.61 27.56,41.38 27.56,35.81 26.49,34.75 24.41,34.75 19.28,29.62 v1(19.13,29.62)
  BOTTOM w0.102: v1(19.13,29.62) 19.13,30.12 v2(18.39,30.86) 18.36,30.89 18.36,32.66 18.59,32.89 18.59,34.65 17.93,35.31 17.93,46.01 13.82,50.12 13.82,51.71 13.44,52.1 v1(12.93,52.1)
PM_SYNC: length 19.4
  TOP w0.089: PCH1.AJ4 51.94,50.73 51.53,50.73 51.44,50.64 46.44,50.64 45.62,51.46 45.06,51.46
  TOP w0.102: 45.06,51.46 42.59,51.46 40.43,53.62 34.87,53.62 R486.1
PME_L: length 10
  TOP w0.089: 59.87,36.96 59.87,37.26 59.54,37.59 59.54,41.39 59.07,41.86 59.07,42.37 58.89,42.56 58.89,43.07 58.69,43.27 PCH1.BD17
  TOP w0.102: R625.1 60.6,34.49 60.6,36.07 59.87,36.8 59.87,36.96
POP: length 59.8
  TOP w0.254: v1(27.69,234.29) 24.76,234.29 v1(24.61,234.44) R10.1 22.93,233.81 21.41,233.81 R9.1 20.14,233.81 18.1,233.81 R8.1 16.83,233.81 15.56,233.81 R7.1 14.24,233.76 12.62,233.76 12.26,234.12 R6.1 ; v1(24.49,238.76) R5.1 22.7,239.62 21.36,239.62 20.77,239.03 R4.1 20.01,239.52 18.23,239.52 R3.1 16.83,239.4 15.56,239.4 R2.1 14.17,239.52 13.02,239.52 R1.1 ; v1(30.3,234.29) 30.3,231.65 37.11,224.84 37.11,218.9 Q6.C
  BOTTOM w0.254: v1(24.61,234.44) 23.8,235.25 v2(23.8,236.68) 23.8,238.07 v1(24.49,238.76) ; v1(30.3,234.29) v1(27.69,234.29)
PROC_SEL_L: length 1.6
  TOP w0.102: CPU1.AB36 v5(139.1,146.2)
  BOTTOM w0.089: v5(139.1,146.2) 139.73,146.2 STP37.1
PROCHOT_L: length 19.5
  TOP w0.102: CPU1.C39 142.13,163.86 v1(142.13,164.52)
  BOTTOM w0.102: v1(142.13,164.52) 142.58,164.52 143.48,165.42 143.48,168.1 146.61,171.22 149.83,171.22 151.1,172.49 v2(151.1,175.36) SR13.2
PROCPWRGD: length 15.5
  TOP w0.089: 45.06,49.83 45.67,49.83 45.95,49.56 51.44,49.56 51.72,49.27 PCH1.AM3
  TOP w0.102: R508.1 37.85,51.21 38.51,50.55 41.17,50.55 41.88,49.83 45.06,49.83
PWM2_B: length 127.3
  TOP w0.203: v1(162.79,207.39) 162.67,207.51 U19.40
  TOP w0.254: U27.3 191.36,140.97 191.74,140.59 v1(192.51,140.59) ; v1(157.2,196.98) 157.68,196.49 174.35,196.49 v1(174.4,196.55)
  BOTTOM w0.254: v1(162.79,207.39) 162.79,206.48 160.52,204.22 159.99,204.22 159.61,203.84 159.61,202.95 156.69,200.03 156.69,197.49 v1(157.2,196.98) ; v1(192.51,140.59) 194.82,140.59 v2(195.45,141.22) 197.36,143.13 197.36,201.68 196.29,202.74 189.41,202.74 188.04,204.11 183.11,204.11 182.55,204.67 179.58,204.67 177.97,203.06 177.97,200.32 174.4,196.75 v1(174.4,196.55)
PWM3_A: length 78.6
  TOP w0.203: v1(162.09,206.76) 162.09,207.96 161.54,208.51 161.54,208.89 161.86,209.2 U19.38
  TOP w0.254: v1(190.35,176.02) 189.96,176.41 U24.3 ; v1(177.27,196.34) 176.86,195.94 156.97,195.94 v1(156.57,196.34)
  BOTTOM w0.254: v1(156.57,196.34) 156.18,196.72 156.18,200.15 159.11,203.07 159.11,204.09 159.74,204.72 160.32,204.72 162.09,206.49 v1(162.09,206.76) ; v1(190.35,176.02) 190.73,176.02 190.74,176.01 191.38,176.01 191.77,176.4 191.77,181.33 v2(190.42,182.68) 189.28,183.82 175.57,183.82 173.33,186.06 173.33,194.56 173.71,194.94 175.11,194.94 176.51,196.34 v1(177.27,196.34)
R_CLKREQB: length 3.1
  TOP w0.102: R206.1 47.19,201.16 47.6,201.57 48.59,201.57 48.75,201.73 U21.12
R_REGOUT:
  vias: v2(55.3,197.89)
RJ45_P19: length 8.4
  TOP w0.508: v1(66.19,221.74) C51.1 65.33,221.72 C55.2
  BOTTOM w0.508: USB2_LAN.P1 71.02,223.47 69.29,221.74 v1(66.19,221.74)
ROM_CS_L0: length 19.2
  TOP w0.102: SPI_DEBUG.1 61.65,10.92 v1(61.14,10.41) ; v1(70.14,9.2) 70.14,7.21 R763.2 C642.1 SPIROM1.1
  BOTTOM w0.102: v1(61.14,10.41) v2(61.9,9.65) 66.43,9.65 67.04,9.04 69.98,9.04 v1(70.14,9.2)
RS_4P7V: length 3.4
  BOTTOM w0.508: SR765.2 SC645.1 SR766.1 SR767.1
RS_4P7V_R: length 1.4
  BOTTOM w0.508: SQ42.B SR767.2
RSET: length 5
  TOP w0.102: U21.31 54.55,202.53 55.09,203.07 57.74,203.07 R183.1
RSMRST_L: length 188.4
  TOP w0.089: PCH1.BA11 55.04,44.8 v3(54.99,44.75)
  TOP w0.102: U38.43 117.95,35.04 118.14,34.85 119.16,34.85 C585.1 120.05,35.03 121.46,35.03 122.21,34.28 R622.1 122.71,34.65 124.51,34.65 125.58,35.71 126.44,35.71 127,35.15 127,33.22 124.82,31.04 124.82,24.33 126.11,23.04 126.11,14.35 v1(126.34,14.12) ; v1(52.1,35.23) 52.1,34.46 C589.1 ; v1(43.66,27.13) R711.1 43.66,25.98 44.73,24.92 46.58,24.92 46.96,24.54 46.96,21.41 46.58,21.03 46.58,19.89 45.97,19.28 45.97,18.11 46.24,17.84 46.24,16.7 45.08,15.54 45.08,14.58 42.8,12.29 v1(42.8,10.57)
  BOTTOM w0.089: 54.51,38.61 54.81,38.91 54.81,43.33 54.96,43.48 54.96,44.72 v3(54.99,44.75)
  BOTTOM w0.102: v1(42.8,10.57) 42.8,7.8 43.13,7.47 43.13,5.05 46.73,1.45 115.11,1.45 117.22,3.56 119.53,3.56 120.22,2.87 123.8,2.87 126.92,5.99 126.92,10.72 126.09,11.56 v2(126.09,12.32) 126.09,13.87 v1(126.34,14.12) 127.2,14.12 127.99,13.34 SQ43.C ; 54.51,38.61 54.51,38.61 52.32,36.43 52.32,35.46 v1(52.1,35.23) 52.02,35.15 52.02,32.16 51.41,31.55 50.62,31.55 46.13,27.05 44.68,27.05 44.6,27.13 v1(43.66,27.13)
RSMRST_Q: length 4.9
  BOTTOM w0.508: SQ42.C 130.4,10.03 SQ43.B 131.42,12.06 132.02,12.67 SR768.2
RSVD_AW2: length 1.5
  TOP w0.089: v3(104.85,130.58) 104.85,130.61 CPU1.AW2
  BOTTOM w0.089: STP5.1 104.93,130.58 v3(104.85,130.58)
RSVD_B39: length 1.8
  TOP w0.089: v3(141.15,164.74) 141.39,164.5 CPU1.B39
  BOTTOM w0.089: STP17.1 140.59,165.3 v3(141.15,164.74)
RSVD_C40: length 1.7
  TOP w0.089: CPU1.C40 142.44,163.12 v3(142.82,162.74)
  BOTTOM w0.089: v3(142.82,162.74) 142.21,162.74 STP26.1
RSVD_J7: length 1.9
  TOP w0.089: CPU1.J7 v3(110.39,159)
  BOTTOM w0.089: STP29.1 111.25,159.87 v3(110.39,159)
RSVD_J8: length 3.6
  TOP w0.089: CPU1.J8 111.3,159.01 v3(111.3,160.81)
  BOTTOM w0.089: STP27.1 111.3,161.77 v3(111.3,160.81)
RSVD_J17: length 2.1
  TOP w0.089: CPU1.J17 v3(118.59,159.03)
  BOTTOM w0.089: v3(118.59,159.03) 117.73,158.17 STP34.1
RSVD_J19: length 2.3
  TOP w0.089: CPU1.J19 120.88,158.55 v3(120.45,158.98)
  BOTTOM w0.089: v3(120.45,158.98) 121.13,158.29 STP33.1
RSVD_K8: length 1.8
  TOP w0.089: CPU1.K8 v3(110.37,158.1)
  BOTTOM w0.089: STP31.1 110.97,158.7 v3(110.37,158.1)
RSVD_K10: length 1.6
  TOP w0.089: v3(113.11,158.06) 113.11,158.07 CPU1.K10
  BOTTOM w0.089: STP32.1 113.59,158.55 v3(113.11,158.06)
RSVD_L8: length 1.5
  TOP w0.089: CPU1.L8 v3(111.28,157.15)
  BOTTOM w0.089: STP36.1 111.28,156.49 v3(111.28,157.15)
RSVD_L10: length 1.6
  TOP w0.089: CPU1.L10 v3(113.11,157.15)
  BOTTOM w0.089: v3(113.11,157.15) 113.41,157.45 STP35.1
RSVD_V1: length 1.6
  TOP w0.508: CPU1.AV1 104.44,131.93 104.01,131.5 v3(103.99,131.5)
  BOTTOM w0.089: STP10.1 103.86,131.37 v3(103.99,131.5)
RTCRST_L: length 270.9
  TOP w0.089: v3(53.92,39.25) 55.5,40.83 55.5,42.49 55.36,42.63 55.36,43.45 55.23,43.58 PCH1.BC10
  TOP w0.102: v1(40.13,28.42) 39.93,28.22 39.93,26.57 39.19,25.83 39.19,23.44 38.63,22.89 38.63,20.29 38.43,20.09 38.43,16.84 36.48,14.88 v1(35.86,14.88) ; v1(122.1,6.63) 124.92,3.81 v1(129.03,3.81) ; v1(191.82,62.28) 190.32,63.78 190.32,66 C482.1 189.27,67.72 R416.2
  BOTTOM w0.089: v3(53.92,39.25) 53.92,38.78 51.59,36.45 51.59,36.32
  BOTTOM w0.102: v1(129.03,3.81) 183.34,3.81 188.24,8.71 188.24,34.01 195.61,41.38 195.61,57.56 v2(191.82,61.34) v1(191.82,62.28) ; v1(35.86,14.88) 36.12,15.14 38.61,15.14 39.8,13.94 42.06,13.94 42.85,13.16 44.7,13.16 47.4,10.46 47.4,8.23 50.17,5.46 53.62,5.46 54.25,4.83 74.47,4.83 75.03,5.38 79.22,5.38 80.39,4.22 100.3,4.22 103.07,6.99 106.22,6.99 108.15,5.05 113.41,5.05 115.29,6.93 121.79,6.93 v1(122.1,6.63) ; v1(40.13,28.42) 40.31,28.6 44.88,28.6 47.01,30.73 47.57,30.73 50.01,33.17 50.01,34.75 51.59,36.32
RTCX1_IN: length 16.1
  TOP w0.089: PCH1.BC9 54.65,43.89 54.9,43.65 54.9,43.14 54.98,43.07 54.98,41.82 v3(53.87,40.72)
  TOP w0.102: R618.1 48.46,35.27 C588.1 48.46,33.48 v1(48.49,33.45) R641.1
  BOTTOM w0.089: 50.42,36.32 52.98,38.89 52.98,39.83 v3(53.87,40.72)
  BOTTOM w0.102: v1(48.49,33.45) 48.36,33.58 v2(48.36,34.26) 50.42,36.32
RTCX1_IN_R: length 1.8
  TOP w0.102: R618.2 47.04,34.87 Y1.1
RTCX2_OUT: length 17.3
  TOP w0.089: PCH1.BD10 55.14,43.18 55.17,43.15 55.17,41.38 v3(53.87,40.08)
  TOP w0.102: v1(49.23,34.16) 49.23,32.52 R641.2 C592.1 46.8,32.33 Y1.2
  BOTTOM w0.089: 50.85,36.32 53.29,38.76 53.29,39.7 53.67,40.08 v3(53.87,40.08)
  BOTTOM w0.102: 50.85,36.32 49.23,34.7 v1(49.23,34.16)
SA0_CHA: length 7.7
  TOP w0.102: DIMM2.117 58.8,96.32 58.8,98.63 57.96,99.47 56.41,99.47 56.01,99.87 55.02,99.87 54.92,99.97 R365.1
SA0_CHB: length 4
  TOP w0.102: DIMM1.117 58.84,88.18 59.59,88.93 R380.1
SA1_CHA: length 2.6
  TOP w0.102: DIMM2.237 60.6,90.72 R381.1
SA1_CHB: length 9.7
  TOP w0.102: DIMM1.237 58.27,82.3 56.92,83.64 56.92,84.89 57.56,85.52 57.56,86.54 56.72,87.38 56.72,88.56 R379.1
SATA3_RX_N0: length 69.7
  TOP w0.089: PCH1.G35 67.89,62.13 68.94,62.13 v3(69.24,61.82)
  BOTTOM w0.089: 70.69,61.62 70.67,61.62 70.67,61.63 69.75,61.63 69.56,61.82 v3(69.24,61.82)
  BOTTOM w0.102: 70.69,61.62 72.47,61.62 73.44,62.59 83.92,62.59 84.79,61.72 86.59,61.72 90.37,57.94 90.37,39.07 89.81,38.51 89.81,32.32 89.64,32.14 89.64,28.7 92.38,25.96 92.38,19.51 v2(92.05,19.18) 92.38,18.85 92.38,18.15 92.53,18 92.53,16.05 92.38,15.9 92.18,15.9 92.05,16.03 SC65.2
SATA3_RX_N2: length 52.4
  TOP w0.102: PCH1.F41 70.05,62.31 v3(69.85,62.51) ; C465.2 102.2,71.06 102.02,71.06 v1(101.67,70.7)
  BOTTOM w0.089: v3(69.85,62.51) 70.13,62.79 70.41,62.79 70.67,63.05 70.67,63.91 70.68,63.92 70.68,63.94
  BOTTOM w0.102: v1(101.67,70.7) 101.66,70.7 101.32,71.04 101.11,71.04 100.84,71.32 100.84,76.96 99.8,78 93.79,78 93.21,78.59 78.51,78.59 69.62,69.7 69.62,67.18 70.68,66.12 70.68,63.94
SATA3_RX_N3: length 49.2
  TOP w0.102: PCH1.D43 71.66,63.07 v3(71.34,63.38) ; v1(90.27,69.39) 89.92,69.04 89.92,68.55 90.72,67.75 91.41,67.75 C473.2
  BOTTOM w0.089: 72.29,63.02 72.28,63.01 71.75,63.01 v3(71.34,63.38)
  BOTTOM w0.102: v1(90.27,69.39) 89.94,69.72 89.94,70.28 88.02,72.2 88.02,73.06 86.18,74.9 77.59,74.9 75.09,72.4 75.09,70.32 75.81,69.6 83.05,69.6 arc(83.46,69.18) 83.05,68.76 78.03,68.76 72.29,63.02
SATA3_RX_P0: length 69.7
  TOP w0.089: v3(69.19,62.48) 69.02,62.32 67.96,62.32 PCH1.E35
  BOTTOM w0.089: v3(69.19,62.48) 69.19,62.46 69.83,61.82 70.66,61.82 70.67,61.82 70.69,61.82
  BOTTOM w0.102: 70.69,61.82 72.39,61.82 73.36,62.79 84.01,62.79 84.87,61.93 86.67,61.93 90.58,58.02 90.58,38.98 90.02,38.42 90.02,32.23 89.84,32.05 89.84,28.79 92.58,26.04 92.58,18.24 92.74,18.08 92.74,17.6 v2(93.07,17.27) 92.74,16.94 92.74,16.55 SC66.2
SATA3_RX_P2: length 52.4
  TOP w0.102: v1(101.67,71.62) 102.02,71.26 102.2,71.26 C453.2 ; PCH1.E41 70.25,62.82 v3(69.88,63.19)
  BOTTOM w0.089: v3(69.88,63.19) 70.09,62.98 70.33,62.98 70.48,63.13 70.48,63.91 70.48,63.92 70.48,63.94
  BOTTOM w0.102: v1(101.67,71.62) 101.66,71.62 101.3,71.25 101.19,71.25 101.04,71.4 101.04,77.05 99.88,78.21 93.88,78.21 93.29,78.79 78.6,78.79 78.6,78.79 78.43,78.79 69.42,69.78 69.42,69.61 69.42,67.1 70.48,66.04 70.48,63.94
SATA3_RX_P3: length 49.2
  TOP w0.102: v1(89.36,69.39) 89.71,69.04 89.71,68.47 90.63,67.55 91.41,67.55 C481.2 ; v3(71.39,62.39) 71.17,62.61 PCH1.E42
  BOTTOM w0.089: v3(71.39,62.39) 71.78,62.82 72.38,62.82
  BOTTOM w0.102: v1(89.36,69.39) 89.74,69.77 89.74,70.2 87.82,72.12 87.82,72.98 86.1,74.7 77.67,74.7 75.29,72.32 75.29,70.4 75.9,69.8 83.05,69.8 arc(83.67,69.18) 83.05,68.55 78.11,68.55 72.38,62.82
SATA3_TX_N0: length 81.9
  TOP w0.102: v3(68.96,66.5) 68.96,66.37 68.81,66.22 68.67,66.22 67.74,65.29 67.74,63.81 PCH1.C36 ; v1(87.88,14.63) 88.11,14.4 88.11,14.01 89.24,12.89 90.11,12.89 90.68,13.45 90.68,13.9 C631.2
  BOTTOM w0.102: v1(87.88,14.63) 88.11,14.86 88.11,17.63 89.89,19.41 89.89,25.16 88.6,26.46 88.6,32.32 89.12,32.85 89.12,38.82 89.69,39.38 89.69,57.45 86.16,60.99 84.07,60.99 83.15,61.9 73.81,61.9 72.8,60.88 69.21,60.88 68.38,61.71 68.38,66.01 68.61,66.24 68.71,66.24 v3(68.96,66.5)
SATA3_TX_N2: length 52.9
  TOP w0.102: PCH1.B39 69.51,64.2 69.75,64.44 69.75,65.18 70.21,65.63 70.21,67.51 70.38,67.69 70.69,67.69 v3(70.89,67.49) ; v1(101.64,67.91) 101.95,67.6 102.23,67.6 C475.2
  BOTTOM w0.102: v3(70.89,67.49) 70.69,67.69 70.38,67.69 70.1,67.96 70.1,69.48 78.68,78.05 78.85,78.05 92.94,78.05 93.47,77.52 99.5,77.52 100.36,76.67 100.36,68.18 100.95,67.59 101.32,67.59 v1(101.64,67.91)
SATA3_TX_N3: length 47.7
  TOP w0.102: v3(72.31,68.1) 72.31,68.27 72.19,68.4 71.81,68.4 71.68,68.27 71.68,66.12 70.38,64.82 70.38,64.68 PCH1.A41 ; C462.2 91.48,71.23 90.68,71.23 89.76,72.16 89.56,72.16 v1(89.37,71.97)
  BOTTOM w0.102: v3(72.31,68.1) 72.64,68.43 73.79,68.43 74.57,69.22 74.57,72.67 77.39,75.49 85.1,75.49 arc(85.62,76.01) 85.1,76.53 79.53,76.53 arc(79.22,76.84) 79.53,77.14 86.08,77.14 87.55,75.67 87.55,74.32 89.48,72.39 89.48,72.09 v1(89.37,71.97)
SATA3_TX_P0: length 81.9
  TOP w0.102: C630.2 89.76,14.33 89.89,14.45 90.3,14.45 90.47,14.27 90.47,13.53 90.03,13.09 89.32,13.09 88.32,14.1 88.32,14.4 88.54,14.63 v1(88.8,14.63) ; v3(69.06,65.79) 69.06,65.89 68.94,66.01 68.76,66.01 67.94,65.2 67.94,64.21 PCH1.B36
  BOTTOM w0.102: v3(69.06,65.79) 69.06,65.94 68.96,66.04 68.69,66.04 68.58,65.93 68.58,61.8 69.29,61.09 72.71,61.09 73.73,62.1 83.24,62.1 84.15,61.19 86.24,61.19 89.89,57.54 89.89,39.29 89.33,38.73 89.33,32.76 88.8,32.23 88.8,26.54 90.09,25.25 90.09,19.32 88.32,17.54 88.32,14.86 88.54,14.63 v1(88.8,14.63)
SATA3_TX_P2: length 52.9
  TOP w0.102: v1(101.64,66.99) 102.05,67.4 102.43,67.4 102.65,67.18 C485.2 ; PCH1.A39 69.55,64.62 69.55,65.26 70,65.72 70,67.6 70.3,67.89 70.76,67.89 70.89,68.02 v3(70.89,68.3)
  BOTTOM w0.102: v1(101.64,66.99) 101.64,67.17 101.42,67.39 100.86,67.39 100.15,68.1 100.15,76.58 99.42,77.32 93.39,77.32 92.85,77.85 78.77,77.85 70.31,69.39 70.31,68.05 70.46,67.89 70.76,67.89 70.89,68.02 v3(70.89,68.3)
SATA3_TX_P3: length 47.6
  TOP w0.102: v1(90.02,72.62) 90.02,72.19 90.77,71.44 91.48,71.44 C452.2 ; v3(72.31,68.91) 72.01,68.61 71.72,68.61 71.48,68.36 71.48,66.2 70.18,64.9 70.18,64.68 PCH1.A40
  BOTTOM w0.102: v1(90.02,72.62) 89.55,72.62 87.76,74.4 87.76,75.71 arc(87.75,75.75) 87.73,75.78 86.19,77.31 arc(86.16,77.34) 86.12,77.34 79.53,77.34 arc(79.02,76.84) 79.53,76.33 85.1,76.33 arc(85.42,76.01) 85.1,75.69 77.31,75.69 74.37,72.75 74.37,69.3 73.7,68.63 72.59,68.63 v3(72.31,68.91)
SATA3R_N2: length 6.1
  TOP w0.102: SATA1.5 108.46,71.11 104.15,71.11 C465.1
SATA3R_N3: length 4.8
  TOP w0.102: SATA2.5 96.39,67.72 93.34,67.72 C473.1
SATA3R_P2: length 6.1
  TOP w0.102: SATA1.6 108.46,71.32 104.04,71.32 C453.1
SATA3R_P3: length 4.8
  TOP w0.102: C481.1 93.26,67.51 96.41,67.51 SATA2.6
SATA3T_N2: length 6.1
  TOP w0.102: C475.1 104.11,67.51 108.46,67.51 SATA1.3
SATA3T_N3: length 4.7
  TOP w0.102: SATA2.3 96.47,71.25 93.39,71.25 C462.1
SATA3T_P2: length 6.1
  TOP w0.102: SATA1.2 108.46,67.31 104.03,67.31 C485.1
SATA3T_P3: length 4.8
  TOP w0.102: SATA2.2 96.32,71.45 93.36,71.45 C452.1
SATA_PCIE_RXN_S: length 11.8
  TOP w0.102: M2_2.41 98.61,14.92 98.45,15.09 97.97,15.09 97.31,15.75 96.23,15.75 95.75,16.23 93.35,16.23 92.66,15.54 92.66,14.5 92.79,14.37 v1(93.08,14.37) 92.66,13.95 92.66,13.77 92.87,13.56 R747.1
  BOTTOM w0.102: SC66.1 92.94,15.14 92.74,14.94 92.74,14.71 v1(93.08,14.37)
SATA_PCIE_RXP_S: length 11.7
  TOP w0.102: M2_2.43 98.63,15.42 98.5,15.29 98.05,15.29 97.39,15.95 96.32,15.95 95.83,16.43 93.27,16.43 92.46,15.62 92.46,14.66 v1(92.16,14.37) 92.16,14.36 92.46,14.07 92.46,13.79 92.22,13.56 R746.2
  BOTTOM w0.102: SC65.1 92.3,15.14 92.53,14.92 92.53,14.74 v1(92.16,14.37)
SATA_PCIE_TXN_S: length 14.3
  TOP w0.102: M2_2.47 98.65,16.42 98.47,16.61 96.69,16.61 95.75,17.55 90.88,17.55 90.3,16.97 90.3,16.31 v1(90.7,15.9) 90.58,15.9 90.27,15.6 90.27,15.16 90.55,14.88 90.78,14.88 90.91,15.01 C631.1
  BOTTOM w0.102: v1(90.7,15.9) 90.5,15.7 90.5,15.14 90.61,15.03 SC68.2
SATA_PCIE_TXP_S: length 14.3
  TOP w0.102: M2_2.49 98.61,16.92 98.5,16.81 96.77,16.81 95.83,17.75 90.8,17.75 90.09,17.05 90.09,16.2 v1(89.79,15.9) 90.07,15.62 90.07,15.39 89.76,15.09 C630.1
  BOTTOM w0.102: SC67.2 89.84,14.96 89.94,14.86 90.2,14.86 90.3,14.96 90.3,15.54 89.94,15.9 v1(89.79,15.9)
SATALED_L: length 137.8
  TOP w0.089: PCH1.AD44 73.1,53.11 74.24,51.97 76.05,51.97
  TOP w0.102: 76.05,51.97 77.98,51.97 80.29,49.66 81.74,49.66 84.07,47.32 86.21,47.32 v1(86.23,47.29) 86.84,46.69 R543.1 ; Q37.E 9.35,12.4 v1(9.45,12.5) 9.94,12.99 R744.1 ; v1(26.44,12.04) 26.44,12.2 24.99,13.65 24.99,15.01 25.73,15.75 25.73,17.5 27.49,19.25 29.03,19.25 30,20.22 30.83,20.22 31.57,20.96 31.57,23.29 33.5,25.22 33.5,26.03 34.32,26.85 v1(34.77,26.85)
  BOTTOM w0.102: v1(26.44,12.04) 26.19,12.29 24.26,12.29 23.8,12.75 21.71,12.75 20.9,11.94 10.97,11.94 10.41,12.5 v1(9.45,12.5) ; v1(34.77,26.85) 35.23,26.85 36.93,25.15 39.17,25.15 41.15,23.16 43.33,23.16 43.43,23.27 47.78,23.27 48.26,23.75 48.26,25.25 50.27,27.25 50.98,27.25 51.18,27.46 53.31,27.46 54.43,26.34 54.43,24.54 56.34,22.63 69.04,22.63 69.37,22.96 69.37,23.66 70.42,24.71 78.97,24.71 82.93,28.68 82.93,37.87 84.66,39.6 84.66,41.1 86.77,43.21 86.77,44.04 85.93,44.88 v2(85.93,46.23) 85.93,46.99 v1(86.23,47.29)
SDI: length 2.7
  TOP w0.102: R152.2 18.89,212.2 CODEC.8
SENSE-A: length 5.3
  TOP w0.254: R140.1 R139.1 R138.1 23.96,212.82 23.01,213.77 23.01,214.51 22.79,214.72 CODEC.13
SENSE-B: length 7.1
  TOP w0.254: CODEC.34 16.39,223.19 15.93,223.65 15.44,223.65 14.45,224.64 13.37,224.64 R32.2 R31.2
SERIRQ: length 95.8
  TOP w0.089: PCH1.BA17 57.94,45.18 v3(57.94,45.21)
  TOP w0.102: v1(54.38,29.54) 54.81,29.11 54.81,28.58 54.48,28.24 53.75,28.24 53.1,27.59 R683.1 51.97,26.64 52.07,26.54 v1(52.07,26.21) ; LPC_DEBUG.16 76.61,20.37 77.8,21.56 79.27,21.56 79.96,22.25 79.96,25.91 82.55,28.5 98.78,28.5 99.82,27.46 105.44,27.46 105.84,27.86 105.84,28.7 106.5,29.36 106.5,31.04 106.9,31.44 U38.15
  BOTTOM w0.102: LPC_DEBUG.16 76,20.37 74.6,18.97 72.21,18.97 71.75,18.52 69.78,18.52 68.79,19.51 61.47,19.51 60.25,20.73 56.9,20.73 56.39,20.22 54.05,20.22 52.07,22.2 v1(52.07,26.21) ; v1(54.38,29.54) 54.64,29.79 54.64,34.54 54.71,34.62 54.71,36.65 55.24,37.19 56.18,37.19 57.2,38.2 57.2,40.69 57.8,41.29 57.8,45.07 v3(57.94,45.21)
SIO_24M: length 101.3
  TOP w0.102: R662.2 59.11,30.15 60.3,28.96 61.37,28.96 63.45,26.87 63.45,22.47 60.53,19.55 60.53,18.64 58.37,16.48 58.37,15.01 57.2,13.84 55.91,13.84 55.07,13 v1(54.69,13) ; U38.23 111.39,28.76 110.95,28.32 108.34,28.32 C613.1 106.57,26.82 106.15,26.39 106.15,24.92 v1(107.04,24.03)
  BOTTOM w0.102: v1(54.69,13) 55.12,12.57 72.49,12.57 75.29,9.78 76.07,9.78 v2(76.5,9.35) 76.81,9.04 89.33,9.04 90.7,7.67 98.35,7.67 102.54,11.86 102.54,20.52 103.4,21.39 104.93,21.39 107.04,23.5 v1(107.04,24.03)
SIO_BEEP: length 117.6
  TOP w0.102: v1(170.46,9.37) 172.95,9.37 184.53,20.96 187.93,20.96 190.63,23.65 R720.2 C614.1 ; R573.1 105.26,40.79 106.58,39.47 109.98,39.47 110.19,39.27 U38.61 110.19,37.36 114.12,33.43 v1(114.12,32.23)
  BOTTOM w0.102: v1(170.46,9.37) 169.37,9.37 v2(169.29,9.3) 168.68,8.69 155.78,8.69 153.34,11.13 151.97,11.13 149.83,8.99 141.91,8.99 132.79,18.11 125.22,18.11 124.21,19.13 124.21,25.4 125.27,26.47 125.27,27.71 121.69,31.29 115.06,31.29 v1(114.12,32.23)
SIO_CLKIN: length 100.4
  TOP w0.102: R722.2 52.65,22.92 54.58,20.98 54.58,20.6 55.63,19.56 55.63,17.83 v1(55.85,17.6) ; U38.25 112.19,28.22 111.3,27.33 110.74,27.33 110.26,26.84 C611.1 110.62,26.26 110.62,24.56 111.23,23.95 114.05,23.95 115.6,22.4 115.6,8.69 111.43,4.52 106.35,4.52 102.46,8.41 97.36,8.41 97.26,8.31 82.91,8.31 v1(79.12,12.09)
  BOTTOM w0.102: v1(55.85,17.6) 55.96,17.5 56.64,17.5 57.68,16.46 58.65,16.46 58.8,16.61 67.87,16.61 68.33,16.15 68.76,15.72 75.08,15.72 v2(75.69,15.11) 78.71,12.09 v1(79.12,12.09)
SIO_GND: length 15.3
  TOP w0.178: v1(118.34,35.44) U38.44
  TOP w0.381: v1(119.61,42.62) 119.94,42.62 120.22,42.9 120.22,43.68 R563.2
  TOP w0.508: v1(118.34,35.44) 119.04,35.44 L24.2 ; R568.2 121.77,42.25 v1(121.77,42.95) ; v1(126.85,38.74) 126.77,38.81 C575.1 R587.1 ; v1(121.69,38.68) 121.11,38.1 C580.1 ; C581.2 126.85,37.74 v1(126.92,37.82) ; C573.2 120.26,39.29 v1(121.02,40.06) ; v1(119.61,42.62) C567.2 ; C565.2 v1(117.32,42.62) ; R581.2 v1(124.18,41.02) ; C564.2 v1(116.18,42.62) ; C566.2 v1(118.47,42.62)
  vias: v1(124.46,35.43)
SIO_LED0: length 176.5
  TOP w0.102: R761.2 R762.2 5.72,10.73 6.02,11.02 v1(6.4,11.02) ; v1(113.36,31.19) 113.08,31.19 111.73,32.54 110.52,32.54 109.22,33.84 U38.9
  BOTTOM w0.102: v1(113.36,31.19) 113.72,30.84 121.46,30.84 124.61,27.69 124.61,26.47 123.72,25.58 123.72,13.82 124.46,13.08 124.46,6.65 122.99,5.18 116.2,5.18 114.68,3.66 107.2,3.66 105.32,5.54 103.47,5.54 100.93,3 53.95,3 52.93,4.01 47.68,4.01 45.95,5.74 45.95,9.93 44.11,11.76 42.29,11.76 41.94,11.4 40,11.4 38.89,12.52 33.4,12.52 30.56,9.68 9.5,9.68 9.19,9.37 7.01,9.37 v2(6.4,9.98) v1(6.4,11.02)
SIO_LED0_R: length 1.6
  TOP w0.102: R761.1 3.64,6.66 Q40.B
SIO_LED1: length 175.9
  TOP w0.102: v1(5.77,11.53) 5.95,11.72 R751.2 R750.1 ; U38.8 109.2,34.24 110.64,32.79 111.86,32.79 112.98,31.67 113.89,31.67 v1(114.1,31.47)
  BOTTOM w0.102: v1(114.1,31.47) 114.53,31.47 114.93,31.06 121.59,31.06 124.87,27.79 124.87,26.39 123.98,25.5 123.98,15.29 v2(124.33,14.94) 124.69,14.58 124.69,6.53 123.09,4.93 116.28,4.93 114.78,3.43 107.1,3.43 105.23,5.31 103.56,5.31 101.02,2.77 53.82,2.77 52.81,3.78 47.55,3.78 45.72,5.61 45.72,9.83 44.02,11.53 42.39,11.53 42.04,11.18 39.9,11.18 38.79,12.29 33.53,12.29 30.67,9.43 9.63,9.43 9.35,9.14 6.35,9.14 5.77,9.73 v1(5.77,11.53)
SIO_LED1_R: length 1.5
  TOP w0.102: Q39.B 3.79,11.4 R750.2
SIO_PECI: length 334.5
  TOP w0.102: v1(12.73,50.47) 14.27,50.47 17.04,53.25 17.04,66.67 25.35,74.97 25.35,82.06 17.99,89.42 17.99,102.26 15.6,104.65 15.6,106.91 22.66,113.97 22.66,117.88 23.15,118.38 23.15,118.38 26.29,121.52 26.29,122.78 34.34,130.84 39.4,130.84 48.44,139.88 53.9,139.88 54.53,140.51 56.36,140.51 64.11,148.26 64.11,156.72 69.49,162.1 69.49,168.71 68.71,169.49 68.71,175.23 67.38,176.56 R267.2 ; v1(30.3,19.15) 30.71,19.56 31.75,19.56 32.84,20.65 v1(32.84,21.21) ; R702.2 113.31,25.37 118.06,20.62 118.06,5.64 116.18,3.76 106.4,3.76 102.23,7.92 97.61,7.92 97.49,7.8 81.86,7.8 v1(76.81,12.85)
  BOTTOM w0.102: v1(76.81,12.85) 76.81,13.21 76.2,13.82 75.21,13.82 73.81,15.21 57.66,15.21 56.41,16.46 54.64,16.46 52.98,14.81 51.77,14.81 46.3,20.27 42.19,20.27 41.33,21.13 32.92,21.13 v1(32.84,21.21) ; v1(30.3,19.15) 30.23,19.08 30.23,16.69 29.31,15.77 27.89,15.77 27.43,16.23 27.43,17.31 26.87,17.88 26.41,17.88 19.99,24.3 19.99,24.64 19.99,25.83 19.96,25.86 19.96,25.87 18.62,27.22 18.62,28.58 17.12,30.08 17.12,45.67 13.54,49.25 12.98,49.25 v2(12.8,49.42) 12.73,49.5 v1(12.73,50.47)
SIO_PECI_R: length 4.3
  TOP w0.102: C612.1 R702.1 113.46,26.99 113.46,27.99 112.99,28.46 U38.27
SIO_PWRON_L: length 157.5
  TOP w0.089: PCH1.AT13 56.04,46.81 v3(56.03,46.81)
  TOP w0.102: v1(75.64,9.04) 76.99,7.7 76.99,3.33 78.77,1.55 117.58,1.55 119.1,3.07 119.1,22.66 118.01,23.75 118.01,25.3 117.68,25.63 117.68,26.46 R697.1 116.94,27.2 116.94,27.66 115.77,28.83 114.76,28.83 114.59,29 U38.31 ; v1(42.01,27) 42.16,26.85 42.16,24.38 41.35,23.57 41.35,19.13 v1(41.25,19.02)
  BOTTOM w0.089: v3(56.03,46.81) 55.63,46.41 55.63,43.35 55.26,42.99 55.26,38.75 54.97,38.46
  BOTTOM w0.102: 54.97,38.46 52.81,36.3 52.81,34.8 52.48,34.47 52.48,31.95 51.59,31.06 50.8,31.06 46.33,26.59 45.21,26.59 44.68,26.06 43.92,26.06 42.98,27 v1(42.01,27) ; v1(41.25,19.02) 41.68,19.02 42.39,18.31 44.7,18.31 45.21,18.82 45.62,18.82 46.13,18.31 46.13,17.32 49.96,13.49 51.87,13.49 53.62,11.73 v2(54.64,11.73) 57.96,11.73 58.32,12.09 72.26,12.09 75.31,9.04 v1(75.64,9.04)
SIO_VCORE: length 10.6
  TOP w0.102: v1(100.15,30.28) 100.2,30.23 101.64,30.23 C603.1
  TOP w0.178: U38.13 106.99,32.24 105.99,31.24 105.99,30.76 105.97,30.73
  TOP w0.254: 105.97,30.73 105.97,29.67 105.64,29.34 C604.1 104.82,28.8 103.06,28.8 C603.1
SIO_VREF: length 7.6
  TOP w0.178: U38.47 117.13,36.64 117.83,37.34
  TOP w0.254: R586.1 121.89,39.88 120.75,38.74 120.05,38.74 C580.2 118.59,38.1 117.83,37.34
SKTOCC_VBOOT: length 4.3
  TOP w0.254: R526.2 155.8,201.96 155.8,200.28 155.42,199.9 Q11.5 154.66,199.9 154.53,199.77 154.53,199.52 154.65,199.4 Q11.6
SLP_AMT_L: length 211.8
  TOP w0.089: 57.73,39.24 57.73,39.73 58.12,40.11 58.12,41.98 57.94,42.16 57.94,42.41 57.65,42.69 57.65,43.48 57.51,43.62 PCH1.BC15
  TOP w0.102: v1(30.38,11.48) 30.71,11.48 33.12,13.89 36.55,13.89 40.28,17.63 40.28,19.56 40.67,19.94 40.67,24.84 41.5,25.68 41.5,27.53 42.39,28.42 46.64,28.42 47.78,27.28 48.92,27.28 51.06,25.14 53.79,25.14 57.12,28.47 57.12,30.35 56.64,30.84 56.64,32.79 57.73,33.88 57.73,39.24
  BOTTOM w0.102: v1(30.38,11.48) 29.49,10.59 10.03,10.59 3.56,17.07 3.56,18.59 2.11,20.04 2.11,80.26 4.47,82.63 4.47,85.27 2.49,87.25 2.49,130.15 3.2,130.86 3.2,135.31 ME_TEST.5
SLP_LAN_L: length 227.3
  TOP w0.089: PCH1.AV15 v3(57.07,46.71)
  TOP w0.102: v1(41.15,24.41) 40.89,24.16 40.89,19.84 40.51,19.46 40.51,12.47 41.1,11.89 v1(41.63,11.89) ; v1(4.22,145.97) 5.03,146.79 5.03,149.85 R292.2
  BOTTOM w0.089: v3(57.07,46.71) 57.52,46.26 57.52,44.99 57.6,44.9 57.6,41.37 56.97,40.74 56.97,38.25 56.11,37.39 55.14,37.39 54.48,36.73 54.48,36.32
  BOTTOM w0.102: v1(4.22,145.97) 4.32,145.87 4.32,142.88 1.42,139.98 1.42,19.61 2.87,18.16 2.87,16.76 9.73,9.91 30.45,9.91 33.3,12.75 38.99,12.75 39.93,11.81 41.55,11.81 v1(41.63,11.89) ; v1(41.15,24.41) 41.4,24.16 43.03,24.16 43.31,24.43 45.28,24.43 45.86,25.02 47.03,25.02 47.31,25.3 47.32,25.3 49.96,27.94 50.62,27.94 51.03,28.35 51.94,28.35 52.68,29.08 53.39,29.08 v2(53.49,29.18) 53.49,29.69 54.41,30.61 54.41,34.65 54.48,34.72 54.48,36.32
