# Allegro board ECS H11H4-AD2 v1.1 boardview.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
CPU_BCLK_P: length 145
  TOP w0.102: PCH1.G2 50.91,61.32 50.09,61.32 49.89,61.52 48.45,61.52 46.81,63.15 46.81,66.73 45.77,67.78 45.77,72.13 47.2,73.56 47.81,73.56 48.18,73.93 48.18,74.22 48.44,74.47 v1(48.67,74.47) ; CPU1.W5 v5(107.64,148.95)
  BOTTOM w0.102: v5(107.64,148.95) 107.38,149.21 105.19,149.21 104.34,148.36 102.18,148.36 101.64,148.89 91.33,148.89 89.55,150.67 86.94,150.67 78.94,142.67 67.36,142.67 52.15,127.46 52.15,114.55 45.19,107.59 45.19,99.15 43.56,97.53 43.56,82.88 48.23,78.21 48.23,75.82 v2(48.56,75.49) 48.23,75.16 48.23,74.7 48.46,74.47 v1(48.67,74.47)
CPU_K12: length 53.2
  TOP w0.102: v5(114.96,158.09) 114.96,158.09 CPU1.K12
  BOTTOM w0.102: STP13.1 75.49,175.41 76.96,175.41 77.62,174.75 97.97,174.75 101.24,171.48 108.48,171.48 110.57,169.39 110.57,168.45 111.25,167.77 111.25,165.79 112.67,164.36 112.67,162.51 113.21,161.98 113.21,160.63 113.56,160.27 113.56,159.77 114.96,158.37 v5(114.96,158.09)
CPU_K13: length 6
  TOP w0.089: CPU1.K13 115.04,157.25 115.04,155.21 R288.1
CPU_L12: length 55.6
  TOP w0.102: CPU1.L12 114.07,157.15 114.07,158.68 113.74,159 v5(113.16,159)
  BOTTOM w0.102: STP12.1 73.02,176.15 74.22,176.15 75.18,175.18 76.83,175.18 77.5,174.52 97.87,174.52 101.14,171.25 108.36,171.25 110.34,169.27 110.34,168.33 111.02,167.64 111.02,165.71 111.71,165.02 111.71,163.04 112.67,162.08 112.67,159.49 v5(113.16,159)
CPU_PCIBCLK_N: length 142.7
  TOP w0.102: v1(46.58,74.34) 46.3,74.34 46.13,74.17 46.13,73.56 45.08,72.52 45.08,67.55 46.13,66.51 46.13,62.86 48.24,60.75 49.66,60.75 49.9,60.51 50.71,60.51 PCH1.J1 ; CPU1.W2 v5(104.9,149.86)
  BOTTOM w0.102: v1(46.58,74.34) 46.33,74.34 46.1,74.57 46.1,75.26 v2(46.43,75.59) 46.1,75.92 46.1,79.35 42.8,82.65 42.8,97.79 44.48,99.47 44.48,107.85 51.41,114.78 51.41,127.7 67.06,143.36 78.64,143.36 86.64,151.36 89.92,151.36 91.67,149.61 102.02,149.61 102.53,149.1 104.07,149.1 104.42,149.45 104.42,149.76 104.6,149.94 104.82,149.94 v5(104.9,149.86)
CPU_PCIBCLK_P: length 142.8
  TOP w0.102: CPU1.W1 v5(103.99,149.86) ; v1(45.67,74.34) 45.92,74.08 45.92,73.64 44.88,72.6 44.88,67.46 45.92,66.42 45.92,62.78 48.16,60.55 49.58,60.55 49.82,60.31 50.89,60.31 51.04,60.45 51.04,60.46 51.21,60.64 PCH1.J2
  BOTTOM w0.102: v1(45.67,74.34) 45.9,74.57 45.9,77.57 v2(45.57,77.9) 45.9,78.23 45.9,79.27 42.6,82.57 42.6,97.87 44.27,99.55 44.27,107.93 51.21,114.87 51.21,127.79 66.98,143.56 78.55,143.56 86.56,151.56 90,151.56 91.75,149.81 102.11,149.81 102.62,149.3 103.99,149.3 104.19,149.5 104.19,149.66 103.99,149.86 v5(103.99,149.86)
CPU_PLTRST_L: length 237.8
  TOP w0.089: PCH1.AK2 51.14,50.4 50.95,50.21 50.95,50.21 50.9,50.16 46.36,50.16 45.52,51 45.06,51
  TOP w0.102: v1(14.1,52.65) 14.66,52.65 16,54 16,66.91 16,67.1 24.31,75.4 24.31,81.63 16.94,88.99 16.94,101.6 14.53,104.01 14.53,107.39 21.54,114.4 21.54,118.24 22.11,118.81 22.11,119.73 22.83,120.45 23.75,120.45 25.2,121.9 25.2,123.32 33.82,131.94 39.02,131.94 48.01,140.93 53.44,140.93 54.07,141.55 55.91,141.55 63.07,148.72 63.07,157.19 68.38,162.49 68.38,168.25 67.38,169.25 R274.1 ; v1(20.45,28.5) 20.5,28.55 20.5,30.18 22.78,32.46 25.35,32.46 26.21,33.32 27.84,33.32 29.41,34.9 29.41,45.31 29.06,45.67 29.06,48.97 32.33,52.25 34.59,52.25 34.87,52.53 34.87,52.93 35.1,53.16 40.23,53.16 42.39,51 45.06,51
  BOTTOM w0.102: v1(14.1,52.65) 14.58,52.17 14.58,50.55 19.08,46.05 19.08,31.45 20.04,30.48 20.04,29.31 20.45,28.91 v1(20.45,28.5)
CPU_PM_DOWN: length 53.8
  TOP w0.102: R273.2 66.02,174.9 66.01,174.9 v1(65.58,175.34) ; v5(110.39,163.58) CPU1.D8
  BOTTOM w0.102: v1(65.58,175.34) v2(66.5,175.34) 68.68,175.34 69.11,174.9 73.86,174.9 75.74,173.02 96.97,173.02 100.45,169.55 107.77,169.55 110.19,167.13 110.19,165.3 110.82,164.67 110.82,164.01 v5(110.39,163.58)
CPU_PM_SYNC: length 277.8
  TOP w0.102: v1(68.94,176.02) 69.11,175.84 69.11,169.67 69.93,168.85 69.93,161.93 64.52,156.52 64.52,148.06 61.24,144.78 61.24,142.32 59.03,140.11 54.74,140.11 54.1,139.47 48.64,139.47 39.6,130.43 34.52,130.43 26.72,122.63 26.72,120.95 25.12,119.35 25.12,118.57 24.84,118.29 24.44,118.29 24.25,118.29 23.29,117.33 23.29,113.7 16.87,107.27 16.87,104.57 18.62,102.82 18.62,98.09 19.1,97.61 19.1,89.2 26.03,82.27 26.03,74.76 17.68,66.4 17.68,52.27 13.44,48.03 12.73,48.03 v1(12.6,48.16) ; CPU1.E8 v5(110.39,162.66) ; R486.2 32.92,53.64 32.92,53.49 28.6,49.17 28.6,45.36 28.96,45.01 28.96,35.1 27.64,33.78 25.96,33.78 25.63,33.45 23.44,33.45 19.66,29.67 19.66,29.41 19.28,29.03 17.04,29.03 v1(16.89,28.88)
  BOTTOM w0.102: v1(12.6,48.16) 12.73,48.03 13.84,48.03 16.48,45.38 16.48,29.29 v1(16.89,28.88) ; v1(68.94,176.02) 69.19,176.02 v2(69.65,175.56) 70.08,175.13 73.99,175.13 75.84,173.28 97.04,173.28 100.54,169.77 107.87,169.77 110.39,167.26 110.39,165.39 111.02,164.75 111.02,163.52 110.39,162.89 v5(110.39,162.66)
CPU_PWROK: length 211.3
  TOP w0.102: R508.2 35.9,50.9 33.1,50.9 30.63,48.44 30.63,43.74 30.84,43.54 30.84,34.59 28.09,31.85 26.75,31.85 25.43,30.53 22.43,30.53 v1(22.07,30.18) ; R275.1 72.88,171.22 72.09,171.22 71.63,170.76 71.63,160.81 65.84,155.02 65.84,147.02 62.79,143.97 62.79,141.91 59.72,138.84 55.35,138.84 54.71,138.2 49.2,138.2 40,129.01 34.95,129.01 31.6,125.65 v1(31.6,123.95)
  BOTTOM w0.102: v1(22.07,30.18) 22.07,31.38 20.85,32.6 20.85,46.81 16.36,51.31 16.36,67.56 15.57,68.35 15.57,78.41 v2(14.63,79.35) 14.63,80.42 11.76,83.29 11.76,101.42 28.32,117.98 28.32,120.19 31.32,123.19 31.32,123.67 v1(31.6,123.95)
CPU_PWROK_RC: length 49.3
  TOP w0.102: v5(110.39,161.75) CPU1.F8 ; R275.2 C257.1 74.24,172.21 v1(76.48,174.45)
  BOTTOM w0.102: v1(76.48,174.45) 76.81,174.12 97.51,174.12 100.84,170.79 108.13,170.79 110.13,168.78 110.13,168.22 110.82,167.54 110.82,165.58 111.46,164.95 111.46,162.74 110.46,161.75 v5(110.39,161.75)
CPU_RST_L_RC: length 56.7
  TOP w0.102: R274.2 67.38,173.16 C256.1 66.82,173.91 66.14,173.91 v1(65.58,174.47) ; v5(109.47,162.66) CPU1.E7
  BOTTOM w0.102: v5(109.47,162.66) 109.55,162.66 109.95,163.07 109.95,167.03 107.65,169.34 100.3,169.34 96.85,172.8 75.64,172.8 73.79,174.65 v2(68.1,174.65) 67.92,174.47 v1(65.58,174.47)
CPU_VIDALERT_L: length 22.2
  TOP w0.102: v1(141.68,165.35) 142.21,165.35 143.36,164.21 143.36,162.41 142.74,161.79 141.88,161.79 CPU1.E39
  BOTTOM w0.102: SR11.2 SC18.1 149.35,174.69 149.35,173.13 v2(148.67,172.44) 148.49,172.44 148.21,172.16 146.18,172.16 142.27,168.25 142.27,165.94 v1(141.68,165.35)
CPU_VIDSCK: length 24.5
  TOP w0.102: v1(142.85,166.14) 144.17,164.82 144.17,161.93 143.12,160.87 140.89,160.87 CPU1.E38
  BOTTOM w0.089: 144.07,169.42 142.85,168.2 v2(142.85,167.36) v1(142.85,166.14)
  BOTTOM w0.102: 144.07,169.42 146.35,171.7 149.15,171.7 150.65,173.2 150.65,174.54 SC19.1 SR12.2
CPU_VIDSOUT: length 20.8
  TOP w0.102: v1(141.68,166.19) 142.01,166.19 143.76,164.44 143.76,162.31 142.75,161.29 CPU1.E40
  BOTTOM w0.102: SR10.2 SC17.1 148.18,174.72 148.18,173.36 147.73,172.9 v2(146.79,172.9) 146.28,172.9 141.68,168.3 v1(141.68,166.19)
CPU_VSS_AB10: length 12.8
  TOP w0.089: v3(54.49,55.06) 54.92,54.51 PCH1.AB10 ; v3(47.45,57.07) 45.44,59.08 45.06,59.08
  TOP w0.102: R453.1 45.06,59.08
  BOTTOM w0.089: v3(54.49,55.06) 54,55.54 52.37,55.54 50.73,57.18 48.72,57.18 48.26,56.72 47.8,56.72 v3(47.45,57.07)
CPU_VSS_AB11: length 13.8
  TOP w0.089: v3(48.08,57.12) 45.06,60.15 ; v3(55.17,55) 55.68,54.49 PCH1.AB11
  TOP w0.102: R450.1 45.01,60.2 45.06,60.15
  BOTTOM w0.089: v3(48.08,57.12) 48.34,57.38 50.8,57.38 52.44,55.73 54.1,55.73 54.31,55.52 54.65,55.52 v3(55.17,55)
DCPRTC: length 16.6
  TOP w0.203: v3(62.76,45.14) 62.99,45.14 PCH1.BA26
  BOTTOM w0.203: v3(62.76,45.14) 62.76,44.73 63.2,44.3 63.2,40.44 64.29,39.34 64.29,34.49 64.95,33.83 v2(65.51,33.83) 65.89,33.45 65.89,30.96 SC58.1
DDI1_AUXN: length 5.7
  TOP w0.089: 114.86,167 114.86,165.53 115.04,165.35 115.04,164.41 CPU1.C13
  TOP w0.102: v1(113.82,168.2) 114.86,167.16 114.86,167
  BOTTOM w0.089: STP15.1 114.22,167.79 v1(113.82,168.2)
DDI1_AUXP: length 5.1
  TOP w0.089: CPU1.B13 115.42,165.28 115.06,165.63 115.06,166.85 115.21,167
  TOP w0.102: 115.21,167 v3(115.47,167.26)
  BOTTOM w0.089: v3(115.47,167.26) 115.77,167.26 116.33,166.7 STP22.1
DDI1_TX_N0: length 106.9
  TOP w0.089: CPU1.D21 123.27,163.65 123.27,164.43 122.95,164.75 122.95,165.68 122.87,165.76 122.87,167.72 121.45,169.14 121.45,169.15 121.44,169.16
  TOP w0.102: 121.44,169.16 116.69,173.91 103.56,173.91 97.56,179.92 97.56,184.45 v1(97.89,184.78) ; C57.1 117.58,220 117.2,219.61 117.2,219.39 v1(117.49,219.1)
  BOTTOM w0.102: v1(117.49,219.1) 117.2,218.81 117.2,218.64 116.89,218.34 115.46,218.34 114.8,219 109.18,219 107.71,217.53 106.48,217.53 99.14,210.19 92.63,210.19 83.64,201.19 83.64,197.94 95.12,186.46 96.93,186.46 97.54,185.86 97.54,185.14 v1(97.89,184.78)
DDI1_TX_N1: length 111.9
  TOP w0.089: 122.43,169.16 122.44,169.15 122.44,169.14 123.56,168.02 123.56,165.72 124.19,165.09 124.19,162.78 124,162.59 123.74,162.59 123.65,162.49 CPU1.E22
  TOP w0.102: v1(119.8,219.12) 119.56,219.36 119.56,219.66 119.89,220 C59.1 ; 122.43,169.16 116.97,174.62 103.94,174.62 99.49,179.07 99.49,184.48 99.8,184.78 v1(99.92,184.78)
  BOTTOM w0.102: v1(119.8,219.12) 119.46,218.78 119.46,218.58 118.52,217.65 115.16,217.65 114.55,218.26 109.42,218.26 107.99,216.84 106.87,216.84 105.82,215.79 105.82,214.42 105.27,213.87 104.45,213.87 104.01,213.87 102.13,211.99 102.13,210.62 100.96,209.45 92.91,209.45 84.4,200.94 84.4,198.17 95.38,187.2 98.66,187.2 99.57,186.29 99.57,185.14 v1(99.92,184.78)
DDI1_TX_N2: length 110.1
  TOP w0.089: 123.47,169.16 123.48,169.15 123.48,169.14 124.21,168.42 124.21,166 124.34,165.86 CPU1.A23
  TOP w0.102: 123.47,169.16 117.19,175.44 104.38,175.44 101.09,178.72 101.09,185.88 v1(101.4,186.18) ; v1(122.06,219.17) 121.85,219.17 121.64,219.38 121.64,219.94 121.84,220.14 122.13,220.14 C61.1
  BOTTOM w0.102: v1(122.06,219.17) 121.84,219.17 121.67,219 121.67,218.48 121.07,217.88 119.77,217.88 118.85,216.97 114.88,216.97 114.27,217.58 109.71,217.58 107.52,215.38 107.52,214.3 106.35,213.13 104.37,213.13 102.92,211.68 102.92,210.39 101.3,208.76 93.22,208.76 85.17,200.71 85.17,198.38 95.54,188.01 99.77,188.01 101.07,186.71 101.07,186.51 v1(101.4,186.18)
DDI1_TX_N3: length 114.3
  TOP w0.089: 124.66,168.99 124.68,168.97 124.68,168.96 125.09,168.54 125.09,163.65 CPU1.D23
  TOP w0.102: C63.1 124.42,220 124.1,219.68 124.1,219.47 v1(124.45,219.12) ; 124.66,168.99 117.51,176.14 104.77,176.14 102.54,178.36 102.54,184.38 v1(102.9,184.73)
  BOTTOM w0.102: v1(102.9,184.73) 102.57,185.06 102.57,186.34 100.11,188.8 95.73,188.8 85.85,198.68 85.85,200.37 93.56,208.08 101.58,208.08 104.63,211.12 106.96,211.12 107.5,211.67 107.5,213.29 108.23,214.02 108.23,215.12 109.97,216.87 113.99,216.87 114.57,216.28 119.16,216.28 120.02,217.14 123.29,217.14 124.08,217.93 124.08,218.75 v1(124.45,219.12)
DDI1_TX_P0: length 106.7
  TOP w0.089: CPU1.C21 122.73,163.76 122.86,163.63 122.95,163.63 123.08,163.75 123.08,164.35 122.76,164.67 122.76,165.61 122.68,165.68 122.68,167.64 121.32,169 121.31,169 121.29,169.02
  TOP w0.102: C56.1 116.99,219.56 116.99,219.44 v1(116.67,219.12) ; 121.29,169.02 116.6,173.71 103.48,173.71 97.36,179.83 97.36,184.43 v1(97,184.78)
  BOTTOM w0.102: v1(97,184.78) 97.33,185.12 97.33,185.78 96.85,186.26 95.04,186.26 83.44,197.86 83.44,201.28 92.55,210.39 99.06,210.39 106.4,217.73 107.62,217.73 109.1,219.2 114.88,219.2 115.54,218.54 116.81,218.54 116.99,218.73 116.99,218.81 v1(116.67,219.12)
DDI1_TX_P1: length 112
  TOP w0.089: 122.28,169.02 122.3,169 122.31,169 123.37,167.94 123.37,165.64 124,165.01 124,162.85 123.92,162.78 123.76,162.78 123.65,162.89 CPU1.D22
  TOP w0.102: v1(118.88,219.12) 119.15,219.12 119.35,219.33 119.35,219.89 119.25,220 C58.1 ; v1(99.03,184.78) 99.29,184.53 99.29,178.99 103.85,174.42 116.88,174.42 122.28,169.02
  BOTTOM w0.102: v1(99.03,184.78) 99.36,185.12 99.36,186.21 98.58,186.99 95.29,186.99 84.2,198.09 84.2,201.02 92.83,209.65 100.88,209.65 101.93,210.7 101.93,212.07 103.93,214.07 104.53,214.07 104.53,214.07 105.18,214.07 105.61,214.5 105.61,215.87 106.78,217.04 107.91,217.04 109.33,218.47 114.64,218.47 115.25,217.86 118.44,217.86 119.25,218.67 119.25,218.97 119.1,219.12 v1(118.88,219.12)
DDI1_TX_P2: length 110
  TOP w0.089: CPU1.B23 124.56,165.28 124.02,165.82 124.02,168.34 123.35,169 123.34,169 123.32,169.02
  TOP w0.102: v1(100.56,186.18) 100.89,185.85 100.89,178.64 104.29,175.23 117.11,175.23 123.32,169.02 ; v1(121.2,219.15) 121.44,219.39 121.44,219.69 C60.1
  BOTTOM w0.102: v1(100.56,186.18) 100.86,186.49 100.86,186.63 99.68,187.81 95.45,187.81 84.96,198.3 84.96,200.8 93.13,208.97 101.21,208.97 102.72,210.47 102.72,211.77 104.28,213.33 106.27,213.33 107.31,214.38 107.31,215.47 109.63,217.78 114.35,217.78 114.96,217.17 118.77,217.17 119.68,218.08 120.99,218.08 121.46,218.56 121.46,218.88 v1(121.2,219.15)
DDI1_TX_P3: length 114.3
  TOP w0.089: 124.52,168.84 124.53,168.83 124.54,168.83 124.9,168.47 124.9,163.73 124.82,163.65 124.65,163.65 124.56,163.74 CPU1.C23
  TOP w0.102: 124.52,168.84 117.43,175.93 104.69,175.93 102.34,178.28 102.34,184.4 v1(102.01,184.73) ; v1(123.53,219.12) 123.9,219.49 123.9,219.82 123.72,220 C62.1
  BOTTOM w0.102: v1(123.53,219.12) 123.88,218.78 123.88,218.02 123.21,217.35 119.94,217.35 119.08,216.48 114.66,216.48 114.07,217.07 109.89,217.07 108.03,215.21 108.03,214.1 107.3,213.38 107.3,211.75 106.88,211.33 104.55,211.33 101.5,208.28 93.47,208.28 85.65,200.46 85.65,198.59 95.65,188.59 100.03,188.59 102.36,186.26 102.36,185.09 v1(102.01,184.73)
DDI2_AUXN: length 4.4
  TOP w0.089: CPU1.B12 114.5,165.34 114.15,165.69 114.15,165.86 113,167
  TOP w0.102: v5(112.32,167.26) 112.75,167.26 113,167
  BOTTOM w0.089: v5(112.32,167.26) 112.32,166.52 STP16.1
DDI2_AUXP: length 4.2
  TOP w0.089: v5(114.17,166.55) 114.5,166.22 CPU1.A12
  BOTTOM w0.089: v5(114.17,166.55) 113.66,167.06 113.66,167.69 113.28,168.07 STP14.1
DDI2_TX_N0: length 117.9
  TOP w0.089: CPU1.A18 119.99,165.61 119.86,165.48 119.79,165.48 119.65,165.62 119.65,166.14 119.75,166.24 119.75,166.78 117.39,169.14 117.39,169.15 117.37,169.16
  TOP w0.102: C76.1 135.11,217.18 134.92,216.99 134.92,216.28 134.49,215.85 133.24,215.85 132.77,216.32 132.77,216.92 v1(132.44,217.25) ; 117.37,169.16 115.44,171.09 102.34,171.09 93.45,179.99 93.45,187.91 86.97,194.39 86.97,199.39 v1(87.35,199.77)
  BOTTOM w0.102: v1(87.35,199.77) 87.07,200.05 87.07,200.6 93.86,207.39 101.94,207.39 104.99,210.44 106.67,210.44 106.68,210.44 107.24,210.44 107.24,210.44 107.44,210.44 108.19,211.18 108.19,212.96 108.92,213.69 108.92,214.84 110.23,216.15 113.68,216.15 114.24,215.6 119.46,215.6 120.28,216.41 130.61,216.41 132.08,217.88 132.64,217.88 132.77,217.75 132.77,217.58 v1(132.44,217.25)
DDI2_TX_N1: length 119.6
  TOP w0.089: CPU1.E18 119.99,162.43 120.08,162.52 120.31,162.52 120.55,162.76 120.55,166.96 118.36,169.14 118.36,169.15 118.35,169.16
  TOP w0.102: v1(88.6,198.17) 88.47,198.17 88.29,197.99 88.29,194.46 94.54,188.21 94.54,179.94 102.68,171.8 115.71,171.8 118.35,169.16 ; C79.1 137.6,217.18 137.36,216.94 137.36,216.71 v1(137.63,216.45)
  BOTTOM w0.102: v1(137.63,216.45) 137.53,216.45 137.31,216.23 137.31,215.93 137.08,215.7 120.55,215.7 119.76,214.91 113.73,214.91 113.28,215.37 110.41,215.37 109.63,214.58 109.63,213.43 108.92,212.72 108.92,210.74 107.8,209.63 105.16,209.63 105.08,209.55 104.35,208.82 102.21,206.68 102.04,206.68 102.04,206.68 94.18,206.68 88.32,200.81 88.32,198.37 88.52,198.17 v1(88.6,198.17)
DDI2_TX_N2: length 119
  TOP w0.089: CPU1.D19 121.25,163.46 121.25,167.31 119.42,169.14 119.42,169.15 119.4,169.16
  TOP w0.102: 119.4,169.16 116.03,172.54 102.93,172.54 95.35,180.12 95.35,188.52 89,194.87 89,197.23 89.53,197.76 89.53,199.62 v1(89.84,199.92) ; C81.1 139.73,216.85 139.73,216.28 v1(139.97,216.04)
  BOTTOM w0.102: v1(89.84,199.92) 89.46,200.3 89.46,200.96 94.46,205.97 102.47,205.97 104.96,208.45 105.39,208.89 108.24,208.89 109.6,210.25 109.6,212.21 110.83,213.44 116.11,213.44 116.9,214.22 120.07,214.22 120.84,214.99 139.28,214.99 139.65,215.36 139.65,215.72 v1(139.97,216.04)
DDI2_TX_N3: length 121.3
  TOP w0.089: CPU1.E20 121.82,162.48 121.92,162.59 122.11,162.59 122.38,162.85 122.38,165.37 122.02,165.73 122.02,167.53 120.41,169.14 120.41,169.15 120.39,169.16
  TOP w0.102: 120.39,169.16 116.33,173.23 103.23,173.23 96.19,180.27 96.19,188.72 90.3,194.61 90.3,195.42 v1(90.63,195.75) ; C83.1 142.01,216.85 142.01,216.2 v1(142.28,215.94)
  BOTTOM w0.102: v1(142.28,215.94) 141.94,215.6 141.94,215.23 141,214.3 121.13,214.3 120.37,213.54 117.27,213.54 116.46,212.72 111.09,212.72 110.39,212.03 110.39,210.03 108.51,208.15 105.66,208.15 102.77,205.26 94.75,205.26 90.93,201.44 90.93,199.62 90.35,199.03 90.35,196.01 90.61,195.75 v1(90.63,195.75)
DDI2_TX_P0: length 117.9
  TOP w0.089: 117.23,169.02 117.24,169 117.25,169 119.56,166.7 119.56,166.32 119.46,166.22 119.46,165.54 119.71,165.29 119.9,165.29 119.99,165.2 CPU1.B18
  TOP w0.102: v1(86.59,199.77) 86.77,199.59 86.77,194.3 93.24,187.82 93.24,179.91 102.26,170.89 115.36,170.89 117.23,169.02 ; C75.1 134.72,216.8 134.72,216.36 134.41,216.05 133.32,216.05 132.97,216.41 132.97,216.87 v1(133.35,217.25)
  BOTTOM w0.102: v1(86.59,199.77) 86.87,200.05 86.87,200.69 93.78,207.59 101.85,207.59 104.9,210.64 106.76,210.64 107.36,210.64 107.98,211.27 107.98,213.05 108.71,213.77 108.71,214.92 110.14,216.36 113.77,216.36 114.33,215.8 119.38,215.8 120.19,216.61 130.52,216.61 132,218.08 132.72,218.08 132.97,217.84 132.97,217.63 v1(133.35,217.25)
DDI2_TX_P1: length 119.6
  TOP w0.089: CPU1.D18 119.99,162.82 120.09,162.71 120.23,162.71 120.36,162.84 120.36,166.88 118.27,168.97 118.27,168.97 118.22,169.01 118.22,169.01 118.2,169.02
  TOP w0.102: v1(136.77,216.45) 137.16,216.84 137.16,217.02 137.01,217.18 C78.1 ; 118.2,169.02 115.63,171.6 102.6,171.6 94.34,179.86 94.34,188.13 88.09,194.38 88.09,198.04 87.93,198.2 v1(87.83,198.2)
  BOTTOM w0.102: v1(87.83,198.2) 87.91,198.2 88.11,198.4 88.11,200.9 94.1,206.88 102.13,206.88 104.27,209.02 104.94,209.69 105.08,209.83 107.71,209.83 108.71,210.83 108.71,212.8 109.42,213.52 109.42,214.67 110.33,215.57 113.36,215.57 113.82,215.11 119.68,215.11 120.46,215.9 137,215.9 137.11,216.01 137.11,216.23 136.89,216.45 v1(136.77,216.45)
DDI2_TX_P2: length 118.8
  TOP w0.089: 119.26,169.02 119.28,169 119.29,169 121.06,167.23 121.06,164.19 CPU1.C19
  TOP w0.102: 119.26,169.02 115.94,172.34 102.84,172.34 95.15,180.04 95.15,188.43 88.8,194.78 88.8,197.32 89.33,197.85 89.33,199.57 v1(88.98,199.92) ; C80.1 139.36,217.18 139.52,217.02 139.52,216.26 139.31,216.04 v1(139.05,216.04)
  BOTTOM w0.102: v1(88.98,199.92) 89.1,199.92 89.26,200.08 89.26,201.05 94.38,206.17 102.39,206.17 104.81,208.6 105.31,209.09 108.15,209.09 109.4,210.34 109.4,212.29 110.74,213.64 116.03,213.64 116.81,214.43 119.99,214.43 120.76,215.2 139.2,215.2 139.45,215.44 139.45,215.82 139.23,216.04 v1(139.05,216.04)
DDI2_TX_P3: length 121.4
  TOP w0.089: CPU1.D20 121.82,162.86 121.91,162.78 122.03,162.78 122.19,162.93 122.19,165.29 121.83,165.65 121.83,167.45 120.28,169 120.27,169 120.25,169.02
  TOP w0.102: 120.25,169.02 116.25,173.02 103.15,173.02 95.99,180.19 95.99,188.64 90.09,194.53 90.09,195.53 v1(89.84,195.78) ; C82.1 141.55,217.18 141.81,216.92 141.81,216.38 v1(141.36,215.94)
  BOTTOM w0.102: v1(141.36,215.94) 141.73,215.57 141.73,215.32 140.92,214.5 121.05,214.5 120.29,213.74 117.19,213.74 116.37,212.93 111,212.93 110.19,212.11 110.19,210.12 108.42,208.36 105.58,208.36 102.68,205.46 94.67,205.46 90.73,201.52 90.73,199.7 90.14,199.12 90.14,195.96 89.96,195.78 v1(89.84,195.78)
DDI3_AUX_N: length 174.2
  TOP w0.089: 101.43,168.59 101.44,168.58 101.45,168.58 101.49,168.54 101.5,168.53 101.51,168.53 110.46,168.53 111.57,167.42 111.57,166.95 113.23,165.29 113.23,164.7 CPU1.C11
  TOP w0.102: v1(80.98,193.4) 81.25,193.12 81.25,192.88 83.71,190.42 86.35,190.42 90.53,186.25 90.53,179.49 101.43,168.59
  BOTTOM w0.102: SC6.1 182.89,227.33 181.71,227.33 v2(181.38,227.66) 181.05,227.33 180.21,227.33 177.7,229.84 163.64,229.84 158.03,224.23 154.5,224.23 151.81,221.54 126.12,221.54 124.98,222.68 114.15,222.68 113,221.54 108.46,221.54 106.81,219.89 105.48,219.89 98.04,212.45 91.61,212.45 81.23,202.07 81.23,193.65 v1(80.98,193.4)
DDI3_AUX_P: length 173.5
  TOP w0.089: 101.57,168.73 101.59,168.72 110.54,168.72 111.76,167.5 111.76,167.03 113.59,165.2 CPU1.B11
  TOP w0.102: 101.57,168.73 90.73,179.58 90.73,186.33 86.43,190.63 83.79,190.63 81.46,192.96 81.46,193.27 v1(81.71,193.52)
  BOTTOM w0.102: SC9.1 183.29,226.67 183.29,226.95 183.11,227.13 v2(179.65,227.13) 179.65,227.6 177.61,229.64 163.73,229.64 158.11,224.03 154.58,224.03 151.89,221.34 126.03,221.34 124.89,222.48 114.23,222.48 113.09,221.34 108.54,221.34 106.89,219.68 105.56,219.68 98.12,212.24 91.69,212.24 81.43,201.98 81.43,193.8 v1(81.71,193.52)
DDI3_TX_N0: length 174.3
  TOP w0.089: 114.76,169.27 116.15,167.87 116.15,166.24 115.98,166.07 115.98,165.57 116.18,165.37 116.32,165.37 116.43,165.48 116.43,165.76 CPU1.A14
  TOP w0.102: v1(84.22,193.6) 83.92,193.3 83.92,193.05 84.87,192.1 86.44,192.1 91.57,186.98 91.57,179.74 101.71,169.59 114.43,169.59 114.76,169.27
  BOTTOM w0.102: SC12.1 182.7,224.8 180.33,224.8 179.91,225.22 v2(179.43,225.22) 179.43,225.7 176.94,228.19 176.53,228.19 175.79,228.93 164.02,228.93 158.38,223.29 154.86,223.29 152.2,220.62 108.8,220.62 107.18,219 105.99,219 98.55,211.56 92.05,211.56 82.22,201.73 82.22,196.98 83.91,195.29 83.91,193.92 v1(84.22,193.6)
DDI3_TX_N1: length 175.5
  TOP w0.089: CPU1.B15 117.24,164.64 117.13,164.53 116.97,164.53 116.88,164.62 116.88,166.22 116.66,166.44 116.66,168.54 116.07,169.14 116.07,169.15 116.05,169.16
  TOP w0.102: 116.05,169.16 114.81,170.41 101.9,170.41 92.46,179.86 92.46,187.55 87.15,192.86 86.12,192.86 85.8,193.18 85.8,193.62 85.98,193.8 v1(86.08,193.8)
  BOTTOM w0.102: v1(86.08,193.8) 85.93,193.8 85.8,193.93 85.8,194.5 82.96,197.34 82.96,201.49 92.34,210.87 98.86,210.87 106.2,218.21 107.42,218.21 109.15,219.94 152.63,219.94 154.2,221.51 157.86,221.51 164.59,228.24 175.31,228.24 175.95,227.61 175.95,225.62 177.61,223.95 180.59,223.95 181.05,223.49 v2(181.05,223.01) 181.53,223.01 182.1,222.44 182.77,222.44 SC14.1
DDI3_TX_P0: length 174.9
  TOP w0.089: CPU1.B14 115.79,165.49 115.79,166.14 115.96,166.32 115.96,167.79 114.69,169.07 114.68,169.07 114.63,169.11 114.62,169.11 114.61,169.12
  TOP w0.102: v1(83.34,193.6) 83.59,193.6 83.72,193.47 83.72,192.96 84.79,191.9 86.36,191.9 91.36,186.89 91.36,179.65 101.63,169.39 114.34,169.39 114.61,169.12
  BOTTOM w0.102: v1(83.34,193.6) 83.7,193.97 83.7,195.2 82.02,196.89 82.02,201.81 91.97,211.76 98.47,211.76 105.91,219.2 107.09,219.2 108.72,220.83 152.11,220.83 154.78,223.49 158.29,223.49 163.93,229.13 175.88,229.13 176.61,228.4 177.02,228.4 177.55,227.86 v2(178.03,227.86) 178.03,227.39 180.41,225.01 182.94,225.01 183.17,225.23 SC11.1
DDI3_TX_P1: length 176.2
  TOP w0.089: 115.91,169.02 115.92,169 115.93,169 116.47,168.47 116.47,166.36 116.69,166.14 116.69,164.54 116.89,164.34 117.13,164.34 117.24,164.22 CPU1.C15
  TOP w0.102: v1(85.32,193.8) 85.6,193.52 85.6,193.09 86.03,192.66 87.06,192.66 92.25,187.47 92.25,179.77 101.82,170.21 114.72,170.21 115.91,169.02
  BOTTOM w0.102: v1(85.32,193.8) 85.6,194.08 85.6,194.41 82.75,197.26 82.75,201.57 92.25,211.07 98.77,211.07 106.11,218.41 107.34,218.41 109.07,220.14 152.54,220.14 154.12,221.72 157.78,221.72 164.51,228.45 175.4,228.45 176.15,227.69 176.15,227.25 v2(176.48,226.92) 176.15,226.59 176.15,225.7 177.7,224.16 180.67,224.16 182.18,222.64 182.94,222.64 183.17,222.87 SC13.1
DDPD_CTRL_CLK: length 19.5
  TOP w0.089: PCH1.BE5 52.61,42.88 50.55,40.82 50.55,39.09 48.41,36.96
  TOP w0.102: 48.41,36.96 48.29,36.83 43.76,36.83 42.47,38.13 37.89,38.13 R593.1
DDPD_CTRL_DATA: length 19.9
  TOP w0.089: 48.74,36.96 50.75,38.97 50.75,40.72 52.65,42.62 52.83,42.62 PCH1.BE6
  TOP w0.102: 48.74,36.96 48.38,36.6 43.67,36.6 42.55,37.72 37.59,37.72 R600.1
DDR3_DRAMRST_L: length 204.3
  TOP w0.102: v1(104.7,13.03) 104.7,12.42 101.73,9.45 97.84,9.45 97.46,9.83 96.5,9.83 95.83,9.17 83.82,9.17 82.83,10.16 82.83,14.14 R739.2 81.03,15.94 C627.1 ; v1(152.48,10.29) 151.33,11.43 151.33,29.97 152.5,31.14 152.5,41.28 151.79,41.99 v1(151.79,42.7) ; DIMM2.168 130.66,93.2 130.66,85.38 DIMM1.168 131.84,80.25 v1(132.08,80.01) ; v1(139.67,8.08) 139.52,7.92 123.39,7.92 121.16,10.16 v1(121.16,10.97) ; v1(157.35,76.86) 156.11,76.86 155.02,75.77 151.84,75.77 150.7,76.91 v1(150.52,76.91)
  BOTTOM w0.102: v1(139.67,8.08) 139.95,8.36 150.19,8.36 152.12,10.29 v1(152.48,10.29) ; v1(121.16,10.97) 120.88,11.25 106.48,11.25 v2(105.64,12.09) v1(104.7,13.03) ; v1(151.79,42.7) 150.49,42.7 149.83,43.36 149.83,48.16 156.13,54.46 157.28,54.46 163.88,61.06 163.88,65.25 159.41,69.72 159.41,72.9 157.35,74.96 v1(157.35,76.86) ; v1(132.08,80.01) 132.23,80.16 141.58,80.16 144.65,77.09 150.34,77.09 v1(150.52,76.91)
DDR_VOLTAGE_SEL: length 33.4
  TOP w0.089: v3(63.8,48.19) PCH1.AR27
  TOP w0.102: v1(77.39,28.8) R680.1
  BOTTOM w0.089: 71.22,36.32 71.22,37.24 67.67,40.79 65.96,40.79 65.46,41.3 65.46,42.6 64.36,43.69 64.36,44.82 64.44,44.89 64.44,47.55 v3(63.8,48.19)
  BOTTOM w0.102: v1(77.39,28.8) 76.8,29.39 v2(76.45,29.39) 70.23,29.39 68.99,30.63 68.99,32.41 69.57,32.99 70.21,32.99 71.22,34.01 71.22,36.32
DDR_VTT_CNTL: length 54.3
  TOP w0.254: v5(138.19,146.2) 138.19,145.29 CPU1.AC36 ; R311.1 180.93,129.13 v1(181.2,128.85)
  BOTTOM w0.254: v1(181.2,128.85) v2(180.09,128.85) 176.4,128.85 157.02,148.23 143.36,148.23 142.32,147.19 139.18,147.19 v5(138.19,146.2)
DDR_VTT_CNTL_EN: length 91.8
  TOP w0.102: v1(157.18,73.28) 156.24,73.28 155.73,73.79 151.77,73.79 R401.2 ; v1(181.86,124.99) 182.63,124.23 R321.2 ; v1(158.6,69.42) 159.05,69.88 162.76,69.88 163.7,70.82 165.15,70.82 v1(165.43,71.09)
  TOP w0.203: R401.2 150.76,73.79 149.1,73.79 C449.2 148.4,73.48 U31.5
  BOTTOM w0.102: v1(165.43,71.09) 165.46,71.07 173.84,71.07 182.75,79.98 182.75,101.27 181.08,102.95 v2(181.08,122.89) 181.08,124.21 v1(181.86,124.99) ; v1(157.18,73.28) 158.6,71.86 v1(158.6,69.42)
DEPOP_N1: length 1.9
  TOP w0.102: Q10.B 41.14,205.91 R172.1
DEPOP_N2: length 1.7
  TOP w0.102: Q8.B 40.58,209.77 R160.1
DEPOP_N3: length 7.7
  TOP w0.102: Q8.E 41.49,211.54 R144.1 ; Q8.E Q7.B ; Q8.E 39.45,210.67 39.45,208.81 Q10.E
DEPOP_N4: length 3.5
  TOP w0.102: R109.2 42.14,216.19 C100.1 42.01,215.27 Q7.E
DEPOP_N5: length 2.9
  TOP w0.102: Q6.B 41.2,216.96 R109.1 R89.2
DEVSLP0: length 91.1
  TOP w0.089: PCH1.AG42 71.14,51.96 71.35,52.17 71.68,52.17 71.77,52.26 72.81,52.26 74,51.07 77.5,51.07 78.66,49.91 78.66,49.78 79.22,49.23
  TOP w0.102: v1(94.77,49.73) 92.74,49.73 90.86,47.85 90.86,45.03 89.53,43.71 87.02,43.71 86.49,44.25 85.32,44.25 85.19,44.12 84.66,44.12 84.12,44.65 84.12,45.08 R550.1 84.33,45.43 82.4,47.37 81.08,47.37 79.22,49.23 ; M2_2.38 106.15,14.17 105.79,13.82 105.79,12.62 102.06,8.89 97.05,8.89 v1(96.9,9.04)
  BOTTOM w0.102: v1(96.9,9.04) 97.87,9.04 99.03,10.21 v2(99.03,12.01) 99.03,27.05 95.81,30.28 95.81,43.89 96.32,44.4 96.32,49.68 95.86,50.14 95.17,50.14 v1(94.77,49.73)
DIMM_CA_CPU_VREF: length 166.3
  TOP w0.254: v1(112.67,79.88) 112.06,79.88 111.61,80.34 111.61,80.42 C426.1 R386.1 ; v1(182.05,99.53) 180.64,100.93 180.64,125.02 156.84,148.82 144.17,148.82 142.52,147.17 142.52,145.96 CPU1.AB40
  BOTTOM w0.254: v1(112.67,79.88) 113.18,80.39 v2(114.66,80.39) 131.04,80.39 131.44,80.8 179.88,80.8 181.33,82.25 181.33,92.35 182.05,93.08 v1(182.05,99.53)
DIMM_DQ_A: length 3.6
  TOP w0.102: 166.32,90.77 C401.1
  TOP w0.254: R377.1 R376.1 R375.2
DIMM_DQ_B: length 4.4
  TOP w0.102: v1(173.71,78.23) R390.1
  TOP w0.254: R390.1 173.63,79.36 C429.1 R389.1 R388.2
DIMM_DQ_CPU_VREF_A: length 84.4
  TOP w0.254: CPU1.AC40 143,144.83 143.71,145.54 143.71,146.51 144.91,147.7 156.34,147.7 179.53,124.51 179.53,99.85 181.36,98.02 C419.1 R382.1
DIMM_DQ_CPU_VREF_B: length 98.9
  TOP w0.254: R392.1 C430.1 181.48,80.31 181.71,80.54 v1(181.71,80.87) 181.71,87.43 183.62,89.33 183.62,96.65 180.09,100.18 180.09,124.76 156.59,148.26 144.53,148.26 143.08,146.81 143.08,145.84 142.53,145.29 141.93,145.29 141.48,144.83 CPU1.AC39
DIMM_S5: length 5.4
  TOP w0.203: U31.6 147.89,73.88 148.44,74.42 C448.2 149.1,74.93 150.76,74.93 R400.2
DIMM_VRCA_A: length 2.3
  TOP w0.254: R373.1 R372.1 105.73,89.66 R374.2
DIMM_VREF_CA: length 31.6
  TOP w0.254: DIMM2.67 108.84,93.85 109.7,92.99 109.7,92.84 109.7,92.33 110.59,91.44 114.91,91.44 115.16,91.19 C408.1 115.07,90.68 113.26,90.68 C397.1 ; R386.2 107.92,81.95 107.92,83.06 108.84,83.97 DIMM1.67 109.48,86.74 109.83,86.74 110.91,87.82 110.91,88.71 111.58,89.38 111.96,89.38 C397.1 ; R373.2 108.4,91.57 109.45,91.57 110.59,90.42 C428.1 111.86,90.42 C397.1
DIMM_VREF_DQ_A: length 21.7
  TOP w0.254: DIMM2.1 179.68,95.44 179.68,91.44 179.35,91.11 179.35,90.4 180,89.74 R382.2 179.9,89.56 176.42,89.56 C400.1 C399.1 173.14,89.66 171.42,89.66 C398.1 169.6,89.36 167.95,89.36 R377.2
DIMM_VREF_DQ_B: length 13.2
  TOP w0.254: C439.1 176.12,80.15 176.01,80.26 C438.1 174.12,80.26 174.09,80.23 R390.2 ; C439.1 C440.1 178.73,80.15 179.52,79.36 R392.2 ; C439.1 176.96,80.62 177.9,81.56 177.9,82.8 178.84,83.74 DIMM1.1
DISPA_BCLK: length 187.9
  TOP w0.102: v1(42.11,100.2) 41.39,99.48 41.39,97.32 39.93,95.86 arc(39.37,95.86) 39.37,96.42 39.78,96.83 arc(39.78,97.35) 39.26,97.35 29.9,87.99 29.9,72.95 30.73,72.11 30.73,55.04 25.81,50.11 25.81,45.9 v1(26.26,45.44) ; v1(31.29,45.14) 31.78,45.62 31.78,48.49 33.53,50.24 37.64,50.24 38.99,48.9 R529.1 ; CPU1.V3 106.04,150.32 105.5,150.86 102.07,150.86 101.52,151.42 98.09,151.42 v1(97.33,152.17)
  BOTTOM w0.102: v1(26.26,45.44) 26.39,45.57 v2(27.08,45.57) 30.86,45.57 v1(31.29,45.14) ; v1(42.11,100.2) 42.62,100.71 42.62,108.31 49.66,115.34 49.66,128.42 62.31,141.07 62.31,143.58 64.93,146.2 77.63,146.2 85.43,154 91.32,154 92.85,152.48 96.04,152.48 96.32,152.76 96.75,152.76 v1(97.33,152.17)
DISPA_BCLK_R: length 9.6
  TOP w0.089: 45.06,49.23 45.72,49.23 45.87,49.07 50.42,49.07 50.63,48.86 50.83,48.86 51.24,49.27 PCH1.AM2
  TOP w0.102: 45.06,49.23 44.17,49.23 43.84,48.9 R529.2
DISPA_SDI: length 164.7
  TOP w0.089: PCH1.AN2 51.03,48.79 50.84,48.6 50.61,48.6 50.34,48.87 45.8,48.87 45.67,49 45.06,49
  TOP w0.102: v1(31.24,44.4) 31.57,44.4 32,44.83 32,48.38 33.64,50.01 37.54,50.01 38.89,48.67 39.9,48.67 40.51,48.06 40.74,48.06 40.92,48.23 43.59,48.23 44.35,49 45.06,49 ; v1(56.62,136.45) 56.87,136.7 60.99,136.7 68.28,143.99 68.28,151.38 70.31,153.42 R284.2 ; v1(26.26,44.7) 25.58,45.39 25.58,50.27 30.48,55.17 30.48,71.98 29.67,72.8 29.67,88.52 v1(42.14,100.99)
  BOTTOM w0.102: v1(26.26,44.7) 27.25,44.7 27.86,45.31 29.67,45.31 v2(30.35,44.63) 30.58,44.4 v1(31.24,44.4) ; v1(42.14,100.99) 42.27,101.12 42.27,108.28 49.43,115.44 49.43,128.55 56.62,135.74 v1(56.62,136.45)
DISPA_SDI_R: length 32.6
  TOP w0.102: CPU1.U1 102.21,151.23 100.53,152.91 92.99,152.91 90.96,154.94 83.97,154.94 82.45,153.42 R284.1
DISPA_SDO: length 187.8
  TOP w0.102: v1(31.27,45.9) 31.27,48.31 33.45,50.5 37.72,50.5 38.53,49.68 39.7,49.68 R524.1 ; v1(96.52,152.17) 97.76,150.93 101.5,150.93 101.77,150.66 104.71,150.66 105.05,150.32 CPU1.V2 ; v1(42.11,99.44) 42.11,93.83 40.77,92.48 39.07,92.48 arc(38.66,92.89) 39.07,93.29 40.07,93.29 arc(40.49,93.71) 40.07,94.13 36.8,94.13 30.15,87.48 30.15,73.13 30.96,72.31 30.96,54.91 26.16,50.11 26.16,46.3 v1(26.29,46.18)
  BOTTOM w0.102: v1(42.11,99.44) 42.85,100.18 42.85,108.2 49.89,115.24 49.89,128.32 62.53,140.97 62.53,143.48 65.03,145.97 77.72,145.97 85.52,153.77 91.23,153.77 92.83,152.17 v1(96.52,152.17) ; v1(31.27,45.9) 31.04,46.13 v2(29.16,46.13) 26.34,46.13 v1(26.29,46.18)
DISPA_SDO_R: length 10.2
  TOP w0.089: PCH1.AM1 50.6,49.33 45.9,49.33 45.75,49.48 45.06,49.48
  TOP w0.102: R524.2 41.41,49.48 45.06,49.48
DM1SPD: length 9.3
  TOP w0.102: DIMM2.236 59.84,96.57 59.03,97.38 59.03,99.03 58.34,99.72 56.49,99.72 55.69,100.52 R362.2
DM2SPD: length 10.7
  TOP w0.102: R378.2 58.17,89.79 57.02,88.65 57.02,87.58 57.81,86.79 57.81,85.32 57.15,84.66 57.15,83.9 57.73,83.31 58.96,83.31 DIMM1.236
DMI_RX_N0: length 144.8
  TOP w0.089: 63.11,66.29 63.11,65.72 63.41,65.42 63.41,64.67 63.21,64.47 63.21,64.01 63.36,63.86 PCH1.C27 ; CPU1.Y4 106.96,148.49 106.86,148.59 106.86,148.77 106.57,149.06 101.51,149.06 100.51,150.06 97.38,150.06
  TOP w0.102: 97.38,150.06 95,150.06 90.66,154.41 84.98,154.41 74.7,144.13 74.7,132.45 76.94,130.22 76.94,129.4 v1(76.68,129.15) ; v1(69.16,72.9) 69.42,72.64 69.42,72.42 69.23,72.24 66.37,72.24 63.11,68.97 63.11,66.29
  BOTTOM w0.102: v1(76.68,129.15) 76.96,128.87 76.96,128.71 76.67,128.42 76.22,128.42 54.1,106.31 54.1,83.67 57.33,80.44 62.07,80.44 68.57,73.94 68.91,73.94 69.42,73.43 69.42,73.15 v1(69.16,72.9)
DMI_RX_N1: length 145.3
  TOP w0.089: 64.06,66.19 64.06,66.17 64.06,66.16 64.06,64.39 63.94,64.27 PCH1.B28 ; CPU1.AA5 107.85,147.57 107.76,147.66 107.76,147.86 107.49,148.13 106,148.13 105.61,148.51 101.02,148.51 100.18,149.35 97.38,149.35
  TOP w0.102: v3(69.11,71.32) 68.86,71.07 68.86,70.87 68.58,70.59 66.4,70.59 64.06,68.26 64.06,66.19 ; 97.38,149.35 94.72,149.35 90.48,153.59 85.34,153.59 75.39,143.65 75.39,132.78 77.79,130.38 78.33,130.38 v1(78.66,130.05)
  BOTTOM w0.102: v3(69.11,71.32) 68.94,71.5 68.94,71.76 67.35,73.35 67.35,74.42 61.86,79.91 57.15,79.91 53.62,83.44 53.62,106.52 75.59,128.49 75.59,129.15 76.82,130.38 78.33,130.38 v1(78.66,130.05)
DMI_RX_N2: length 145.8
  TOP w0.089: CPU1.AB3 106.63,146.66 106.69,146.72 106.69,146.93 106.62,147 105.98,147 105.91,146.93 105.38,146.93 104.52,147.79 100.43,147.79 99.74,148.48 97.47,148.48 97.47,148.47 97.41,148.47 97.4,148.46 97.38,148.46 ; 64.81,65.91 64.81,65.89 64.81,65.88 64.81,65.82 64.59,65.6 64.59,64.39 64.45,64.26 PCH1.B29
  TOP w0.102: 97.38,148.46 94.25,148.46 90.11,152.6 85.81,152.6 76.28,143.07 76.28,133.65 77.52,132.41 78.67,132.41 79.26,131.83 79.71,131.83 79.88,132 79.88,132.21 v1(79.73,132.36) ; 64.81,65.91 64.81,67.84 66.55,69.57 68.07,69.57 68.25,69.39 v3(68.25,69.34)
  BOTTOM w0.089: v3(68.25,69.34) 68.25,69.41 68.06,69.61 67.87,69.61 67.65,69.82 67.65,70.88 67.25,71.28 67.25,71.28 67.21,71.32 67.2,71.32 67.19,71.33
  BOTTOM w0.102: 67.19,71.33 66.4,72.12 66.4,73.98 61.38,78.99 56.76,78.99 52.73,83.02 52.73,107.75 63.06,118.08 63.86,118.08 69.16,123.39 69.16,124.19 77,132.03 79.05,132.03 79.26,131.83 79.71,131.83 79.88,132 79.88,132.21 v1(79.73,132.36)
DMI_RX_N3: length 146.9
  TOP w0.089: PCH1.B30 64.82,64.27 64.82,65.19 65.24,65.61 65.24,65.62 65.25,65.63 ; 97.38,147.98 99.53,147.98 100.06,147.45 104.37,147.45 105.52,146.29 107.65,146.29 107.83,146.1 107.83,145.84 107.92,145.75 CPU1.AC5
  TOP w0.102: 65.25,65.63 65.33,65.71 65.33,67.45 66.21,68.33 68.61,68.33 68.65,68.29 v3(68.81,68.45) ; v1(80.41,132.92) 80.15,133.17 77.97,133.17 76.76,134.38 76.76,142.78 86.07,152.1 89.94,152.1 94.05,147.98 97.38,147.98
  BOTTOM w0.102: v3(68.81,68.45) 68.63,68.28 68.43,68.28 67.21,69.49 67.21,70.59 65.91,71.88 65.91,73.61 61.16,78.36 56.69,78.36 52.25,82.8 52.25,107.98 62.86,118.59 63.65,118.59 68.68,123.62 68.68,124.41 76.91,132.64 79.03,132.64 79.56,133.17 80.15,133.17 v1(80.41,132.92)
DMI_RX_P0: length 144.6
  TOP w0.089: 63.31,66.14 63.3,66.16 63.3,65.8 63.49,65.6 63.6,65.5 63.6,64.59 63.4,64.39 63.4,64.21 PCH1.B27 ; CPU1.Y3 106.55,148.49 106.67,148.6 106.67,148.69 106.49,148.87 101.43,148.87 100.43,149.87 97.47,149.87 97.47,149.87 97.41,149.87 97.4,149.86 97.38,149.86
  TOP w0.102: v1(77.6,129.15) 77.3,129.15 77.14,129.31 77.14,130.3 74.9,132.54 74.9,144.04 85.06,154.2 90.58,154.2 94.92,149.86 97.38,149.86 ; v1(70.08,72.9) 69.8,72.9 69.62,72.72 69.62,72.34 69.32,72.03 66.45,72.03 63.31,68.89 63.31,66.14
  BOTTOM w0.102: v1(77.6,129.15) 77.31,129.15 77.17,129.01 77.17,128.63 76.76,128.22 76.3,128.22 54.31,106.22 54.31,83.75 57.41,80.65 62.15,80.65 68.66,74.14 68.99,74.14 69.62,73.52 69.62,73.08 69.8,72.9 v1(70.08,72.9)
DMI_RX_P1: length 145.2
  TOP w0.089: 63.86,66.19 63.86,66.17 63.87,66.16 63.87,64.57 PCH1.A28 ; 97.38,149.15 100.11,149.15 100.94,148.32 105.53,148.32 105.92,147.94 107.41,147.94 107.57,147.78 107.57,147.65 107.49,147.57 CPU1.AA4
  TOP w0.102: 63.86,66.19 63.86,68.34 66.31,70.79 68.5,70.79 68.66,70.95 68.66,71.17 68.51,71.31 v3(68.43,71.31) ; v1(78.66,131.09) 78.79,130.95 78.79,130.68 78.69,130.58 77.88,130.58 75.59,132.87 75.59,143.56 85.42,153.39 90.4,153.39 94.64,149.15 97.38,149.15
  BOTTOM w0.102: v1(78.66,131.09) 78.79,130.95 78.79,130.68 78.69,130.58 76.73,130.58 75.39,129.24 75.39,128.57 53.42,106.6 53.42,83.35 57.07,79.71 61.77,79.71 67.14,74.33 67.14,73.27 68.73,71.68 68.73,71.53 68.52,71.31 v3(68.43,71.31)
DMI_RX_P2: length 145.9
  TOP w0.089: 97.38,148.67 99.82,148.67 100.51,147.98 104.6,147.98 105.46,147.12 105.83,147.12 105.9,147.19 106.7,147.19 106.88,147.01 106.88,146.79 107.01,146.66 CPU1.AB4 ; 64.61,65.91 64.61,65.9 64.4,65.68 64.4,64.47 64.23,64.3 64.23,63.89 64.45,63.67 PCH1.C29
  TOP w0.102: v3(68.3,69.97) 68.11,69.77 66.46,69.77 64.61,67.92 64.61,65.91 ; v1(79.73,131.29) 79.4,131.62 79.17,131.62 78.59,132.21 77.44,132.21 76.07,133.57 76.07,143.15 85.72,152.81 90.2,152.81 94.34,148.67 97.38,148.67
  BOTTOM w0.089: v3(68.3,69.97) 68.13,69.8 67.94,69.8 67.84,69.9 67.84,70.96 67.34,71.46 67.34,71.47 67.33,71.48
  BOTTOM w0.102: 67.33,71.48 66.6,72.21 66.6,74.06 61.47,79.2 56.85,79.2 52.93,83.11 52.93,107.67 63.14,117.88 63.94,117.88 69.37,123.31 69.37,124.1 77.09,131.83 78.97,131.83 79.17,131.62 79.4,131.62 v1(79.73,131.29)
DMI_RX_P3: length 146.8
  TOP w0.089: 65.4,65.49 65.38,65.48 65.37,65.48 65.01,65.11 65.01,64.59 PCH1.A30 ; 97.38,147.78 97.4,147.78 97.41,147.78 97.47,147.78 97.47,147.79 99.45,147.79 99.99,147.26 104.29,147.26 105.45,146.1 107.57,146.1 107.64,146.02 107.64,145.87 107.52,145.75 CPU1.AC4
  TOP w0.102: v3(68.81,67.64) 68.81,67.85 68.53,68.12 66.29,68.12 65.53,67.36 65.53,65.62 65.4,65.49 ; v1(80.41,133.83) 80.41,133.54 80.24,133.38 78.05,133.38 76.96,134.47 76.96,142.7 86.16,151.89 89.85,151.89 93.97,147.78 97.38,147.78
  BOTTOM w0.102: v1(80.41,133.83) 80.41,133.54 80.24,133.38 79.48,133.38 78.94,132.84 76.83,132.84 68.48,124.49 68.48,123.71 63.57,118.8 62.78,118.8 52.04,108.06 52.04,82.72 56.61,78.16 61.08,78.16 65.71,73.52 65.71,71.8 67.01,70.5 67.01,69.41 68.34,68.07 68.58,68.07 68.81,67.85 v3(68.81,67.64)
DMI_TX_N0: length 144.9
  TOP w0.089: 97.38,147.09 99.19,147.09 99.56,146.72 104.04,146.72 104.85,145.91 104.85,145.83 104.76,145.75 CPU1.AC1 ; v3(63.8,60.02) 63.8,59.8 63.59,59.61 PCH1.L27
  TOP w0.102: v1(78.36,135.23) 78.36,134.93 78.23,134.8 77.93,134.8 77.67,135.05 77.67,142.32 86.54,151.18 89.59,151.18 93.68,147.09 97.38,147.09
  BOTTOM w0.089: 67,62.19 67,62.17 67,62.16 67,61.74 65.98,60.71 64.98,60.71 64.49,60.23 64.49,59.93 64.2,59.64 63.96,59.64 63.8,59.8 v3(63.8,60.02)
  BOTTOM w0.102: 67,62.19 67,65.39 64.97,67.41 64.97,69.36 63.65,70.68 63.65,72.33 59.91,76.07 55.69,76.07 49.96,81.81 49.96,103.91 48.91,104.96 48.91,106.96 62.17,120.22 62.98,120.22 66.32,123.55 66.32,125.51 67.66,126.85 68.75,126.85 76.7,134.8 78.23,134.8 78.36,134.93 v1(78.36,135.23)
DMI_TX_N1: length 136.2
  TOP w0.089: CPU1.AD2 105.69,144.83 105.75,144.9 105.75,145.05 105.63,145.17 104.09,145.17 103.1,146.16 99.24,146.16 99,146.41 98.99,146.41
  TOP w0.101: v3(62.76,62.3) PCH1.E24
  TOP w0.102: 98.99,146.41 92.41,146.41 89.81,143.81 87.92,143.81 83.29,139.19 81.05,139.19 80.49,138.63 80.49,136.68 v1(80.75,136.42)
  BOTTOM w0.089: 60.08,70.21 60.09,70.2 60.1,70.2 62.36,67.94 62.36,66.24 63.4,65.2 63.4,64.16 63.17,63.93 63.17,61.99 63.12,61.94 62.94,61.94 62.76,62.13 v3(62.76,62.3)
  BOTTOM w0.102: 60.08,70.21 59.33,70.96 59.33,71.75 57.12,73.96 54.83,73.96 45.21,83.58 45.21,96.71 47.07,98.56 47.07,107.09 58.67,118.7 58.67,120.24 59.61,121.18 61.14,121.18 64.95,124.99 64.95,126.14 67.3,128.5 68.42,128.5 77.11,137.19 80.17,137.19 80.47,136.89 80.47,136.7 v1(80.75,136.42)
DMI_TX_N2: length 133
  TOP w0.089: v3(63.8,61.54) 63.8,61.75 63.61,61.9 PCH1.G27 ; 97.38,145.69 97.4,145.69 97.41,145.7 98.76,145.7 98.88,145.58 102.03,145.58 103.41,144.2 104.11,144.2 104.17,144.25 104.68,144.25 104.78,144.15 104.78,143.97 104.72,143.92 CPU1.AE1
  TOP w0.102: v1(82.93,135.97) 83.29,136.32 83.62,136.32 83.9,136.59 83.9,138.48 88.47,143.05 90.04,143.05 92.68,145.69 97.38,145.69
  BOTTOM w0.089: 61.21,70.36 61.23,70.34 61.23,70.33 63.14,68.42 63.14,66.62 64.25,65.51 64.25,63.12 64.4,62.97 64.4,62.13 64.2,61.93 64.03,61.93 63.8,61.69 v3(63.8,61.54)
  BOTTOM w0.102: 61.21,70.36 60.22,71.35 60.22,72.62 57.99,74.85 55.22,74.85 46.1,83.97 46.1,96.33 47.96,98.19 47.96,106.71 65.84,124.59 65.84,125.76 67.58,127.5 68.69,127.5 77.27,136.07 78.68,136.07 79.39,135.36 81.05,135.36 81.99,136.3 82.6,136.3 v1(82.93,135.97)
DMI_TX_N3: length 135.9
  TOP w0.089: 98.48,145.21 98.5,145.21 98.51,145.2 101.82,145.2 103.25,143.76 104.01,143.76 104.22,143.56 105.74,143.56 105.93,143.37 105.93,143.14 106.07,143 CPU1.AF3 ; v3(65.22,59.25) PCH1.L29
  TOP w0.102: v1(81.46,133.89) 81.81,134.25 81.81,134.6 82.16,134.95 83.3,134.95 84.4,136.05 84.4,138.3 88.54,142.44 90.12,142.44 92.88,145.21 98.48,145.21
  BOTTOM w0.089: 67.89,61.93 67.89,61.92 67.89,61.91 67.89,61.36 66.07,59.54 65.51,59.54 v3(65.22,59.25)
  BOTTOM w0.102: 67.89,61.93 67.89,66.68 68.05,66.83 68.05,67.67 66.52,69.19 66.52,70.18 65.23,71.48 65.23,73.08 60.66,77.65 56.41,77.65 51.54,82.52 51.54,108.28 62.56,119.3 63.37,119.3 67.54,123.47 67.54,125.43 67.94,125.83 69.12,125.83 76.64,133.35 78.75,133.35 80.04,134.65 81.68,134.65 81.81,134.51 81.81,134.25 v1(81.46,133.89)
DMI_TX_P0: length 145
  TOP w0.089: PCH1.N27 v3(63.8,59.25) ; 97.38,147.29 97.4,147.29 97.41,147.29 97.47,147.29 97.47,147.28 99.27,147.28 99.63,146.91 104.11,146.91 105.04,145.99 105.04,145.83 105.13,145.75 CPU1.AC2
  TOP w0.102: 97.38,147.29 93.76,147.29 89.67,151.38 86.45,151.38 77.47,142.4 77.47,134.97 77.84,134.59 78.08,134.59 v1(78.36,134.32)
  BOTTOM w0.089: 67.2,62.19 67.2,62.17 67.19,62.16 67.19,61.66 66.06,60.52 65.06,60.52 64.68,60.15 64.68,59.86 64.27,59.45 63.99,59.45 v3(63.8,59.25)
  BOTTOM w0.102: v1(78.36,134.32) 78.08,134.59 76.78,134.59 68.83,126.64 67.74,126.64 66.52,125.43 66.52,123.47 63.07,120.02 62.26,120.02 49.11,106.87 49.11,105.05 50.16,104 50.16,81.89 55.78,76.28 59.99,76.28 63.86,72.42 63.86,70.76 65.18,69.44 65.18,67.5 67.2,65.47 67.2,62.19
DMI_TX_P1: length 136.3
  TOP w0.089: 98.99,146.61 99.01,146.61 99.02,146.6 99.07,146.6 99.32,146.35 103.17,146.35 104.17,145.36 105.7,145.36 105.94,145.13 105.94,144.93 106.04,144.83 CPU1.AD3 ; v3(62.76,61.54) PCH1.G24
  TOP w0.102: 98.99,146.61 92.32,146.61 89.73,144.02 87.83,144.02 83.21,139.4 80.97,139.4 80.29,138.72 80.29,136.7 v1(79.98,136.4)
  BOTTOM w0.089: v3(62.76,61.54) 62.97,61.75 63.2,61.75 63.36,61.91 63.36,63.85 63.59,64.08 63.59,65.28 62.55,66.32 62.55,68.02 60.24,70.33 60.24,70.34 60.22,70.36
  BOTTOM w0.102: 60.22,70.36 59.54,71.04 59.54,71.84 57.21,74.17 54.91,74.17 45.42,83.67 45.42,96.62 47.27,98.48 47.27,107.01 58.88,118.62 58.88,120.16 59.7,120.98 61.22,120.98 65.15,124.91 65.15,126.06 67.39,128.3 68.5,128.3 77.19,136.98 80.09,136.98 80.26,136.8 80.26,136.68 v1(79.98,136.4)
DMI_TX_P2: length 133.1
  TOP w0.089: 97.38,145.9 97.4,145.9 97.41,145.89 98.84,145.89 98.96,145.77 102.11,145.77 103.49,144.39 104.04,144.39 104.09,144.44 104.76,144.44 104.97,144.23 104.97,144.05 105.1,143.92 CPU1.AE2
  TOP w0.101: v3(63.8,62.3) PCH1.E26
  TOP w0.102: 97.38,145.9 92.6,145.9 89.96,143.26 88.38,143.26 83.69,138.57 83.69,136.68 83.54,136.53 83.29,136.53 v1(82.93,136.88)
  BOTTOM w0.089: 61.07,70.21 61.08,70.2 61.09,70.2 62.95,68.34 62.95,66.54 64.06,65.43 64.06,63.04 64.21,62.89 64.21,62.2 64.12,62.12 63.99,62.12 v3(63.8,62.3)
  BOTTOM w0.102: v1(82.93,136.88) 82.55,136.5 81.91,136.5 80.97,135.56 79.48,135.56 78.77,136.27 77.18,136.27 68.61,127.7 67.49,127.7 65.63,125.84 65.63,124.67 47.75,106.79 47.75,98.27 45.9,96.42 45.9,83.89 55.14,74.65 57.9,74.65 60.02,72.53 60.02,71.26 61.07,70.21
DMI_TX_P3: length 135.9
  TOP w0.089: 98.48,145 98.5,145 98.51,145.01 101.74,145.01 103.17,143.57 103.93,143.57 104.14,143.37 105.66,143.37 105.74,143.29 105.74,143.08 105.66,143 CPU1.AF2 ; PCH1.K29 v3(65.22,60.02)
  TOP w0.102: 98.48,145 92.97,145 90.2,142.24 88.63,142.24 84.61,138.22 84.61,135.97 83.39,134.75 82.25,134.75 82.02,134.52 82.02,134.01 82.14,133.89 v1(82.37,133.89)
  BOTTOM w0.089: 67.69,61.93 67.69,61.92 67.7,61.91 67.7,61.44 65.99,59.73 65.51,59.73 v3(65.22,60.02)
  BOTTOM w0.102: v1(82.37,133.89) 82.14,133.89 82.02,134.01 82.02,134.59 81.76,134.85 79.96,134.85 78.66,133.55 76.56,133.55 69.04,126.03 67.86,126.03 67.34,125.51 67.34,123.55 63.29,119.51 62.48,119.51 51.33,108.36 51.33,82.44 56.33,77.44 60.57,77.44 65.02,72.99 65.02,71.39 66.32,70.1 66.32,69.11 67.84,67.58 67.84,66.91 67.69,66.76 67.69,61.93
DPG: length 17
  TOP w0.254: v1(136.55,218.85) 136.63,218.92 R80.2 ; v1(138.81,218.87) 138.91,218.97 R82.2 ; v1(140.16,218.85) 140.06,218.95 R83.2 ; v1(135.56,218.85) 135.48,218.92 R79.2 ; R78.2 v1(134.34,218.9) ; v1(142.42,218.9) 142.34,218.97 R85.2 ; R81.2 v1(137.77,218.87) ; R84.2 v1(141.2,218.87)
  TOP w0.508: v1(142.42,218.9) 142.7,218.9 v1(143.36,218.24) 143.83,217.76 QN9.3
  BOTTOM w0.381: v1(134.34,218.9) 134.39,218.85 v1(135.56,218.85) v1(136.55,218.85) 137.74,218.85 v1(137.77,218.87) v1(138.81,218.87) 140.13,218.87 v1(140.16,218.85) 141.17,218.85 v1(141.2,218.87) 142.39,218.87 v1(142.42,218.9)
DPG2: length 16.8
  TOP w0.254: R58.2 v1(119.99,221.69) ; v1(116.54,221.69) 116.56,221.72 R51.2 116.56,222.41 116.06,222.41 v1(115.32,221.67) 115.02,221.37 QN5.3 ; v1(121.08,221.67) 121.13,221.72 R59.2 ; R61.2 123.42,221.74 v1(123.37,221.69) ; R56.2 v1(117.7,221.69) ; R57.2 118.85,221.74 v1(118.8,221.69) ; R60.2 v1(122.28,221.69) ; R62.2 v1(124.56,221.69)
  BOTTOM w0.254: v1(124.56,221.69) v1(123.37,221.69) v1(122.28,221.69) 121.11,221.69 v1(121.08,221.67) 121.06,221.69 v1(119.99,221.69) v1(118.8,221.69) v1(117.7,221.69) v1(116.54,221.69)
DPVGA_AUX_N: length 13.8
  TOP w0.102: v1(189.66,223.71) 189.9,223.71 189.97,223.77 189.97,224.03 189.36,224.64 189.36,224.97 189.24,225.09 U7.18
  BOTTOM w0.102: SC6.2 184.45,227.28 185.1,227.28 185.57,226.8 185.57,225.69 186.66,224.59 186.66,222.86 187.68,221.84 189.31,221.84 189.89,222.43 189.89,223.48 v1(189.66,223.71)
DPVGA_AUX_P: length 14.5
  TOP w0.102: v1(190.47,223.73) 190.22,223.73 190.17,223.78 190.17,224.11 189.56,224.72 189.56,224.97 189.64,225.05 U7.19
  BOTTOM w0.102: SC9.2 184.12,226.92 184.28,227.08 185.01,227.08 185.37,226.72 185.37,225.6 186.46,224.51 186.46,222.78 187.6,221.64 189.39,221.64 190.09,222.34 190.09,223.35 v1(190.47,223.73)
DPVGA_DDCCLK: length 33.4
  TOP w0.102: U7.12 186.84,224.31 187.27,223.88 v1(188.76,223.88) 189.05,224.16 189.05,224.69 188.84,224.9 U7.17
  BOTTOM w0.102: v1(188.76,223.88) 188.76,224.09 190.45,225.78 190.45,229.82 189.92,230.35 186.89,230.35 184.99,232.26 184.99,233.91 183.92,234.98 175.87,234.98 173.38,232.49 SR3.1
DPVGA_DDCSDA: length 31.8
  TOP w0.102: U7.13 187.24,225.14 187.12,225.02 187.12,224.38 187.38,224.13 187.93,224.13 v1(188.39,224.59) 188.44,224.64 U7.16
  BOTTOM w0.102: v1(188.39,224.59) 188.39,224.61 189.05,225.27 v2(189.05,225.3) 189.59,225.3 190.22,225.93 190.22,229.69 189.79,230.12 186.77,230.12 184.72,232.17 184.72,233.85 183.82,234.75 175.97,234.75 172.89,231.67 SR4.1
DPVGA_HPD: length 467.4
  TOP w0.089: v3(52.55,45.9) PCH1.AV4
  TOP w0.102: v1(175.21,227.25) 175.18,227.28 175.18,230.28 174.78,230.68 174.78,234.57 v1(175.11,234.9) ; v1(153.01,224.87) 153.01,224.66 153.92,223.75 153.92,220.93 v1(154.3,220.55) ; v1(14.45,13.54) 14.91,13.54 16.59,15.21 20.17,15.21 26.87,21.92 26.87,22.28 28.88,24.28 28.88,24.97 v1(29.18,25.27) ; R17.1 190.6,232.23 v1(190.22,231.85) 189.86,231.85 189.24,231.23 U7.33
  BOTTOM w0.089: 45.57,45.09 47.07,45.09 47.83,45.85 51.13,45.85 51.56,46.28 52.17,46.28 v3(52.55,45.9)
  BOTTOM w0.102: v1(14.45,13.54) 14,13.08 11.66,13.08 10.34,14.4 10.34,18.9 10.64,19.2 10.64,20.98 9.86,21.77 9.86,25.83 4.9,30.78 4.9,65.22 7.32,67.63 7.32,85.81 6.5,86.63 6.5,86.68 6.43,86.76 6.43,86.82 6.05,87.2 6.05,101.78 11.66,107.4 11.66,107.59 11.66,181.33 10.92,182.07 10.92,190.22 11.66,190.96 11.66,193.45 12.93,194.72 12.93,198.17 14.53,199.77 21.38,199.77 27.76,206.15 36.14,206.15 42.79,212.8 43.96,212.8 45.75,214.58 47.73,214.58 48.97,215.82 60.38,215.82 62.13,217.58 84.65,217.58 91.71,224.64 124.77,224.64 125.97,223.44 145.87,223.44 146.79,224.36 152.6,224.36 153.01,224.76 v1(153.01,224.87) ; v1(175.21,227.25) 174.75,227.71 164.95,227.71 157.78,220.55 v2(155.98,220.55) v1(154.3,220.55) ; v1(190.22,231.85) 188.98,230.61 186.97,230.61 185.22,232.36 185.22,234.01 184,235.23 175.44,235.23 v1(175.11,234.9) ; v1(29.18,25.27) 29.18,25.55 29.08,25.65 29.08,28.04 28.8,28.32 28.8,33.02 30.23,34.44 30.23,38.74 33.4,41.91 38.81,41.91 41.99,45.09 45.57,45.09
DPVGA_PWD: length 6.4
  TOP w0.102: U7.31 190.04,230.63 190.55,230.63 191.95,232.03 192.89,232.03 v1(194.03,233.17)
  BOTTOM w0.102: STP2.1 v1(194.03,233.17)
DPVGA_RSCD: length 5.5
  TOP w0.102: v1(189.81,234.37) 190.04,234.14 190.04,232.36 188.84,231.16 U7.34
  BOTTOM w0.102: v1(189.81,234.37) STP1.1
DPVGA_RSET: length 4.4
  TOP w0.102: U7.3 185.59,228.89 184.91,229.57 184.91,231.7 184.33,232.28 R18.1
DPVGA_SCL: length 2.7
  TOP w0.102: R16.2 189.46,232.11 188.44,231.09 U7.35
DPVGA_SDA: length 2.4
  TOP w0.102: R12.2 188.37,231.34 188.04,231.02 U7.36
DPVGA_TX_N0: length 20.3
  TOP w0.102: U7.23 190.99,226.89 191.09,226.79 191.22,226.79 191.92,226.09 192.37,226.09 v1(192.73,226.44)
  BOTTOM w0.102: SC12.2 184.59,224.8 184.98,224.8 185.75,224.03 185.75,222.5 187.3,220.95 192.15,220.95 194.01,222.81 194.01,225.5 193.4,226.11 193.06,226.11 v1(192.73,226.44)
DPVGA_TX_N1: length 23.7
  TOP w0.102: U7.26 191.06,228.09 191.19,227.97 193.37,227.97 193.84,227.5 194.14,227.5 v1(194.5,227.86)
  BOTTOM w0.102: SC14.2 184.63,222.55 184.73,222.55 187.01,220.27 193.07,220.27 195.71,222.91 195.71,226.86 195.05,227.51 194.84,227.51 v1(194.5,227.86)
DPVGA_TX_P0: length 19.6
  TOP w0.102: v1(192.73,225.53) 192.37,225.88 191.84,225.88 191.13,226.59 191.08,226.59 190.99,226.49 U7.22
  BOTTOM w0.102: v1(192.73,225.53) 193.11,225.91 193.31,225.91 193.8,225.42 193.8,222.89 192.07,221.16 187.38,221.16 185.95,222.59 185.95,224.11 185.06,225.01 184.59,225.01 SC11.2
