# Allegro board ECS H11H4-AD2 v1.1 boardview.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
DPVGA_TX_P1: length 22.9
  TOP w0.102: U7.25 191.09,227.69 191.16,227.76 193.29,227.76 193.75,227.3 194.14,227.3 v1(194.5,226.94)
  BOTTOM w0.102: v1(194.5,226.94) 194.76,227.2 194.86,227.3 194.97,227.3 195.5,226.77 195.5,222.99 192.98,220.47 187.1,220.47 184.81,222.76 184.55,222.76 SC13.2
DPVGA_URDBG: length 3.9
  TOP w0.102: U7.24 192.85,227.29 193.83,226.31 TP3.1
DPWROK: length 100.8
  TOP w0.089: v3(55.03,46.05) 55.3,46.33 PCH1.AV11
  TOP w0.102: U38.7 106.71,34.64 C591.1 104.87,33.76 101.71,33.76 R637.1 99.72,33.27 Q32.C 98.44,34.55 96.55,36.45 95.61,36.45 95.43,36.27 95.43,33.5 95.07,33.15 90.96,33.15 88.06,30.25 79.76,30.25 77.65,28.14 77.65,23.09 76.58,22.02 75.29,22.02 v1(74.96,22.35) ; v1(50.47,26.77) 49.78,27.46 49.78,28.27 49.12,28.93 C606.1 R672.1 47.81,29.05 v1(47.22,29.64)
  BOTTOM w0.089: v3(55.03,46.05) 54.58,45.61 54.58,39.01 54.31,38.74 54.31,38.73
  BOTTOM w0.102: v1(47.22,29.64) 50.83,33.25 v2(50.83,33.83) 50.83,34.85 52.1,36.12 52.1,36.52 54.31,38.73 ; v1(50.47,26.77) 50.84,26.77 51.27,27.2 52.5,27.2 53.01,26.7 53.01,23.29 54.38,21.92 60.86,21.92 61.72,21.06 70.05,21.06 70.94,21.95 74.55,21.95 v1(74.96,22.35)
DQ_REF_A_RC: length 1.5
  TOP w0.254: C419.2 v1(182.14,89.74) R383.1
DQ_REF_B_RC: length 1.8
  TOP w0.254: R393.1 180.39,78 v1(180.39,78.64) 180.39,78.85 C430.2
DRAM_RESET_L: length 53.5
  TOP w0.089: 57.28,36.96 57.28,40.14 57.65,40.51 57.65,41.91 57.56,42 57.56,42.25 57.26,42.54 57.26,43.06 57.22,43.1 57.16,43.16 57.16,43.63 56.93,43.87 PCH1.BC14
  TOP w0.102: v1(68.88,23.19) 69.8,22.28 69.8,19.91 71.75,17.96 75.82,17.96 77.41,16.36 R737.1 ; U43.1 78.8,15.72 78.18,16.33 77.62,16.33 R737.1 ; R737.1 76.46,15.18 R738.1 ; 57.28,36.96 57.28,34.11 56.18,33.02 56.18,30.61 56.67,30.12 56.67,28.68 55.04,27.05 v1(54.41,27.05)
  BOTTOM w0.102: v1(54.41,27.05) 54.66,26.8 54.66,24.64 56.44,22.86 66.04,22.86 v2(66.45,23.27) 68.81,23.27 v1(68.88,23.19)
DRAMRST: length 5.9
  TOP w0.102: R738.2 77.41,14.87 77.93,14.35 78.41,14.35 78.71,14.66 79.55,14.66 79.67,14.78 U43.4 81,15.02 R739.1 81.98,14.03 R742.2
EDP_HPD: length 21.3
  TOP w0.089: 49.07,36.96 50.95,38.84 50.95,40.64 52.7,42.39 53,42.39 53.43,42.82 53.43,43.04 53.63,43.23 PCH1.BD7
  TOP w0.102: R603.1 37.74,36.47 38.73,37.47 42.42,37.47 43.51,36.37 48.49,36.37 49.07,36.96
EDP_RCOMP: length 4.3
  TOP w0.203: 112.95,154.74 112.52,154.74 111.76,155.5 CPU1.M9
  TOP w0.305: R285.1 114.25,153.44 112.95,154.74
EUP_SW_N1: length 3.4
  TOP w0.254: R522.1 C536.2 v1(139.29,48.46) 139.62,48.13 Q31.B
EUP_SW_N3: length 28
  TOP w0.254: v1(153.57,54.69) 153.57,55.33 R462.2 ; Q31.C 139.29,45.39 139.83,44.85 C555.1 139.12,44.45 v1(139.06,44.4) 139.01,44.45 R555.1 ; R554.2 v1(143.13,44.58)
  BOTTOM w0.254: v1(153.57,54.69) 153.57,53.8 149.63,49.86 143.26,49.86 142.77,49.38 v2(142.77,48.51) 142.77,47.47 143.51,46.74 143.51,44.96 v1(143.13,44.58) 142.95,44.4 v1(139.06,44.4)
EXTTS_SNI_DRV0_PCH: length 19.7
  TOP w0.089: v1(75.54,49.83) 75.54,49.81 78.21,47.14 79.22,47.14 ; v3(70.15,51.49) PCH1.AF41
  TOP w0.102: 79.22,47.14 79.75,47.14 80.8,46.1 81.31,46.1 84.77,42.64 R567.1
  BOTTOM w0.089: v3(70.15,51.49) 70.38,51.26 71.7,51.26 72.03,50.93 75.08,50.93 75.54,50.47 v1(75.54,49.83)
EXTTS_SNI_DRV1_PCH: length 13.3
  TOP w0.089: PCH1.BD24 61.96,43.16 61.99,43.13 61.99,38.77 61.54,38.33 61.54,37.74 61.93,37.36
  TOP w0.102: 61.93,37.36 61.93,32.51 v2(61.8,32.38) 61.39,31.98 60.69,31.98 R658.1
FAN_CTL1: length 192.4
  TOP w0.178: 106.72,36.64 U38.2
  TOP w0.254: R349.2 v1(184.91,112) R350.1 ; 106.72,36.64 105.84,37.52 104.01,37.52 103.3,36.8 v1(103.02,36.8)
  BOTTOM w0.254: v1(103.02,36.8) 103.25,36.58 103.25,35.71 105.49,33.48 116.1,33.48 117.6,31.98 121.97,31.98 128.57,25.37 130.63,25.37 138.05,17.96 177.15,17.96 183.57,24.38 183.57,43.99 183.56,44 183.56,55.23 180.39,58.39 180.39,62.92 183.74,66.27 183.74,77.77 184.58,78.61 184.58,98.2 188.7,102.31 188.7,108.22 v2(185.9,111.01) v1(184.91,112)
FAN_CTL1_R: length 6.7
  TOP w0.254: CPU_FAN.4 189.03,109.85 186.88,112 R350.2
FAN_CTL2: length 112.9
  TOP w0.178: U38.4 106.35,35.84
  TOP w0.254: v1(180.31,44.58) 180.31,45.83 R538.1 ; v1(105.92,35.74) 105.99,35.81 106.32,35.81 106.35,35.84 ; R538.1 179.17,46.83 R537.1 ; R538.1 178.2,45.72 R546.2
  BOTTOM w0.254: v1(105.92,35.74) 106.55,35.1 116.79,35.1 118.31,33.58 122.61,33.58 129.06,27.13 131.19,27.13 138.71,19.61 176.45,19.61 181.94,25.1 181.94,42.72 v2(181.1,43.56) 180.31,44.35 v1(180.31,44.58)
FAN_CTL2_OP_P2: length 11.1
  TOP w0.254: R537.2 177.42,47.63 v1(177.42,47.75) ; v1(177.21,54.1) 177.09,54.1 C526.1 175.91,55.28 U34.2
  BOTTOM w0.254: v1(177.42,47.75) v2(177.42,51.28) 177.42,53.9 v1(177.21,54.1)
FAN_CTL2_OP_P3: length 5
  TOP w0.102: R483.1 179.8,54.01 v1(180.01,53.8)
  TOP w0.254: R483.1 178.85,54.01 R482.1 177.32,55.55 177.32,55.55 177.18,55.69 U34.3
FAN_TAC1: length 190.3
  TOP w0.254: R352.2 184.13,110.87 v1(184.89,110.87) R351.2 ; v1(103.43,38.02) 104.77,38.02 C577.1 105.59,38.61 107.07,37.12 U38.1
  BOTTOM w0.254: v1(103.43,38.02) 103.76,37.69 103.76,36.02 105.71,34.06 116.28,34.06 117.83,32.51 122.17,32.51 128.75,25.93 130.81,25.93 138.23,18.52 176.88,18.52 183.03,24.67 183.03,54.97 179.86,58.14 179.86,63.17 183.21,66.52 183.21,78 184.07,78.87 184.07,99.11 v2(186.89,101.93) 188.19,103.23 188.19,107.57 v1(184.89,110.87)
FAN_TAC1_R: length 8.1
  TOP w0.254: R351.1 186.78,110.73 D16.P 187.95,108.05 R358.1 191.65,108.05 CPU_FAN.3
FAN_TAC2: length 119.2
  TOP w0.178: U38.3 106.39,36.24
  TOP w0.254: v1(105.36,36.27) 105.35,36.28 C583.1 105.66,36.96 106.39,36.24 ; v1(180.27,50.13) R527.2 R506.2
  BOTTOM w0.254: v1(105.36,36.27) 105.23,36.14 105.23,35.31 105.97,34.57 116.59,34.57 118.11,33.05 122.4,33.05 128.88,26.57 130.99,26.57 138.51,19.05 176.66,19.05 182.5,24.89 182.5,43.41 180.27,45.64 v2(180.27,49.19) v1(180.27,50.13)
FP_PWRBTN_L: length 150.6
  TOP w0.102: D23.3 15.13,11.59 15.5,11.96 v2(16.03,11.96) 16.21,11.79 R756.1 16.84,9.37 v1(16.84,7.47) ; v1(118.74,2.03) 119.36,2.65 119.36,22.16 122.31,25.1 R710.1 121.87,25.81 121.26,25.2 120.36,25.2 C615.1 118.8,26.76 118.8,27.15 118.34,27.61 117.65,27.61 116.19,29.07 U38.33
  BOTTOM w0.102: v1(118.74,2.03) 117.7,0.99 29.87,0.99 27.13,3.73 26.42,3.73 25.81,3.12 20.04,3.12 19.35,3.81 19.35,7.37 18.62,8.1 17.48,8.1 v1(16.84,7.47)
FP_RST_L: length 73.6
  TOP w0.089: 45.06,44.98 49.78,44.98 50.63,45.83 PCH1.AW1
  TOP w0.102: C638.1 20.01,9.21 D24.3 20.09,9.69 20.09,13.03 v1(20.02,13.11) ; C638.1 17.88,8.89 19.1,7.67 19.1,6.63 18.14,5.66 F_PANEL.7 ; C638.1 18.52,9.84 18.52,11.33 R749.2 ; 45.06,44.98 42.29,44.98 40.36,43.05 40.36,41.55 38.76,39.95 v1(38.25,39.95) 38.05,39.75 R589.1 ; v1(31.09,30.99) 31.1,30.99 32.82,29.27 32.82,25.53 30.89,23.6 30.89,22.5 28.46,20.08 27.66,20.08 25.25,17.66 25.25,16.99 23.32,15.06 v1(23.32,13.97)
  BOTTOM w0.102: v1(31.09,30.99) 30.35,31.72 30.35,32.95 31.5,34.1 31.5,38.22 33.4,40.13 36.12,40.13 36.47,39.78 38.07,39.78 v1(38.25,39.95) ; v1(23.32,13.97) 23.06,14.22 21.87,14.22 20.75,13.11 v1(20.02,13.11)
FRONT_JD: length 82.9
  TOP w0.254: R140.2 26.65,211.73 34.21,211.73 35.51,213.03 35.51,223.9 28.5,230.91 28.5,236.91 32.64,241.05 43.33,241.05 44.7,242.42 46.89,242.42 50.8,238.51 57.89,238.51 59.03,237.36 59.03,235.46 56.87,233.3 52.46,233.3 AUDIO.23
FRONT_L: length 100.8
  TOP w0.254: Q3.C1 16.34,237.12 16.61,236.85 18.82,236.85 v1(19.2,236.47) ; R105.1 53.07,219.12 L5.1 53.05,219.16 v1(52.3,219.91) ; R74.1 3.63,219.74 v1(3.45,219.56)
  BOTTOM w0.254: v1(52.3,219.91) 53.05,219.91 54.51,221.37 v2(54.51,221.89) 54.51,227.91 52.07,230.35 52.07,234.14 50.83,235.38 50.83,237.49 50.37,237.95 44.91,237.95 41.02,241.83 22.61,241.83 19.51,238.73 19.51,237.54 19.2,237.24 v1(19.2,236.47) 19.2,235.94 18.75,235.48 18.08,235.48 16.79,236.78 16.79,238.51 15.85,239.45 9.47,239.45 2.31,232.28 2.31,220.7 v1(3.45,219.56)
FRONT_L1: length 13.1
  TOP w0.254: CODEC.35 15.89,222.85 15.65,223.09 15.27,223.09 14.25,224.1 8.97,224.1 8.18,223.32 6.86,223.32 EC1.1
FRONT_L2: length 8.5
  TOP w0.254: R74.2 3.63,224.87 4.75,225.98 6.69,225.98 EC1.2
FRONT_L_P: length 1.4
  TOP w0.254: Q3.B1 16.99,234.92 R8.2
FRONT_LL: length 20.9
  TOP w0.254: AUDIO.24 49.9,230.12 54.05,230.12 57.38,226.8 57.38,223.65 55.59,221.86 D5.2 55.1,220.35 54.74,220.72 C67.1 53.27,220.72 L5.2
FRONT_R: length 107.1
  TOP w0.254: v1(18.44,236.17) 18.44,235.89 18.15,235.6 Q3.C2 ; R102.1 59.97,218.13 L3.1 59.5,219.19 v1(59.11,218.8) ; v1(3.48,216.84) 3.61,216.71 R130.1
  BOTTOM w0.254: v1(59.11,218.8) 59.11,221.18 57.15,223.14 57.15,227.08 54.61,229.62 54.61,233.86 53.37,235.1 53.37,237.59 52.48,238.48 45.16,238.48 41.3,242.34 22.33,242.34 19,239.02 19,237.95 v2(18.44,237.39) v1(18.44,236.17) 18.21,236.17 17.37,237.01 17.37,238.89 16.23,240.03 9.25,240.03 1.75,232.54 1.75,218.57 v1(3.48,216.84)
FRONT_R1: length 15
  TOP w0.254: CODEC.36 15.31,222.23 13.97,223.57 9.3,223.57 5.33,219.6 EC4.1
FRONT_R2: length 5.8
  TOP w0.254: R130.2 3.64,213.29 7.52,217.17 EC4.2
FRONT_R_P: length 1.4
  TOP w0.254: Q3.B2 16.99,238.28 R3.2
FRONT_RR: length 15
  TOP w0.254: AUDIO.21 55.84,229.07 57.89,227.03 57.89,222.38 57.49,221.98 D5.1 57.88,220.75 C65.1 59.81,220.75 L3.2
GLAN_CLKN: length 184.5
  TOP w0.089: PCH1.D3 51.49,62.79 51.34,62.79 v3(51.22,62.91)
  TOP w0.102: v1(48.64,198.68) 48.64,199.11 49.3,199.77 49.3,200.09 49.39,200.18 49.8,200.18 U21.16
  BOTTOM w0.102: v3(51.22,62.91) 51.38,62.74 51.38,62.59 49.65,60.86 39.96,60.86 37.14,58.04 28.08,58.04 27,59.11 27,71.82 26.7,72.12 26.7,82.8 33.17,89.28 33.17,109.67 40.28,116.78 40.28,176.83 42.29,178.83 42.29,184.98 43.03,185.72 43.03,199.25 44.76,200.99 45.75,200.99 47.57,199.16 48.51,199.16 48.64,199.03 v1(48.64,198.68)
GLAN_CLKP: length 184.6
  TOP w0.089: PCH1.F2 51.73,62.42 v3(51.82,62.51)
  TOP w0.102: U21.15 49.45,200.53 49.1,200.18 49.1,199.86 48.84,199.59 48.69,199.59 v1(48.56,199.72)
  BOTTOM w0.102: v1(48.56,199.72) 48.21,199.36 47.66,199.36 45.83,201.19 44.68,201.19 42.82,199.34 42.82,185.8 42.09,185.06 42.09,178.92 40.08,176.91 40.08,116.87 32.97,109.75 32.97,89.37 26.49,82.89 26.49,72.04 26.8,71.74 26.8,59.03 27.99,57.84 37.22,57.84 40.04,60.66 49.73,60.66 51.59,62.51 v3(51.82,62.51)
GLAN_RX_C_N6: length 7
  TOP w0.102: C206.2 46.56,196.39 46.37,196.58 46.37,197.15 46.86,197.64 48.88,197.64 49.74,198.5 50.38,198.5 50.65,198.77 50.65,199.06 50.77,199.18 U21.18
GLAN_RX_C_P6: length 7
  TOP w0.102: C205.2 46.03,196.39 46.16,196.52 46.16,197.23 46.77,197.84 48.79,197.84 49.66,198.7 50.29,198.7 50.44,198.86 50.44,199.06 50.37,199.14 U21.17
GLAN_RX_N6: length 169.7
  TOP w0.102: PCH1.G22 60.74,61.9 v3(60.38,61.54) ; C206.1 46.51,195.1 46.51,193.52 46.28,193.29 46.16,193.29 46.08,193.29 v1(45.72,192.94)
  BOTTOM w0.089: v3(60.38,61.54) 60.1,61.83 59.92,61.83 59.73,62.01 59.73,64.06 59.83,64.16 59.83,66.71 59.32,67.22 57.18,67.22 56.98,67.42
  BOTTOM w0.102: 56.98,67.42 54.17,70.23 49.41,70.23 47.35,68.17 44.9,68.17 40.43,72.64 33.65,72.64 30.05,76.25 30.05,82.02 35.84,87.82 35.84,108.66 42.82,115.65 42.82,169.88 46.89,173.94 46.89,190.16 46.33,190.72 46.33,193.19 46.23,193.29 46.08,193.29 v1(45.72,192.94)
GLAN_RX_P6: length 169.7
  TOP w0.102: C205.1 46.04,195.43 46.3,195.17 46.3,193.61 46.19,193.5 46.08,193.5 v1(45.72,193.85) ; v3(60.38,62.3) 60.74,62.66 PCH1.E22
  BOTTOM w0.089: v3(60.38,62.3) 60.1,62.02 59.99,62.02 59.92,62.09 59.92,63.98 60.02,64.08 60.02,66.79 59.4,67.41 57.28,67.41 57.13,67.56
  BOTTOM w0.102: 57.13,67.56 54.25,70.43 49.33,70.43 47.27,68.38 44.98,68.38 40.51,72.85 33.74,72.85 30.25,76.34 30.25,81.94 36.04,87.73 36.04,108.58 43.03,115.56 43.03,169.79 47.09,173.85 47.09,190.25 46.53,190.8 46.53,193.28 46.31,193.5 46.08,193.5 v1(45.72,193.85)
GLAN_TX_C_N6: length 4.5
  TOP w0.102: C198.2 47.19,198.93 47.42,199.16 47.68,199.16 47.93,199.42 47.93,200.56 48.39,201.02 49.33,201.02 49.41,200.93 U21.14
GLAN_TX_C_P6: length 4.4
  TOP w0.102: U21.13 49.44,201.33 49.33,201.22 48.3,201.22 47.73,200.64 47.73,199.5 47.59,199.36 47.45,199.36 47.19,199.62 C196.2
GLAN_TX_N6: length 171.6
  TOP w0.089: 60.71,65.91 60.71,65.85 61.24,65.31 61.24,64.21 PCH1.B22
  TOP w0.102: 60.71,65.91 60.71,67.15 59.38,68.48 58.85,68.48 58.5,68.12 58.32,68.12 v3(58.06,67.87) ; v1(45.36,198.69) 45.71,199.03 45.97,199.03 46.23,198.77 C198.1
  BOTTOM w0.102: v1(45.36,198.69) 45.73,199.06 45.9,199.06 47.09,197.87 47.09,191.13 47.78,190.44 47.78,173.79 43.51,169.53 43.51,115.34 36.55,108.38 36.55,87.05 30.76,81.25 30.76,76.53 33.96,73.33 40.73,73.33 45.15,68.91 47.12,68.91 49.13,70.92 54.66,70.92 57.4,68.17 57.76,68.17 v3(58.06,67.87)
GLAN_TX_P6: length 171.6
  TOP w0.089: PCH1.A23 61.43,64.67 61.43,65.39 60.91,65.91 60.91,65.94 60.91,65.94
  TOP w0.102: 60.91,65.94 60.91,67.23 59.46,68.68 58.77,68.68 58.41,68.33 58.29,68.33 v3(58.06,68.55) ; v1(45.36,199.61) 45.73,199.24 46,199.24 46.23,199.47 C196.1
  BOTTOM w0.102: v1(45.36,199.61) 45.68,199.29 45.96,199.29 47.29,197.95 47.29,191.21 47.98,190.53 47.98,173.71 43.71,169.44 43.71,115.26 36.75,108.3 36.75,86.96 30.96,81.17 30.96,76.61 34.04,73.54 40.81,73.54 45.24,69.11 47.04,69.11 49.04,71.12 54.75,71.12 57.49,68.38 57.89,68.38 v3(58.06,68.55)
GLED0: length 5
  TOP w0.102: F_PANEL.2 10.34,6.93 R760.2 6.34,5.38 Q40.C
GLED1: length 9.3
  TOP w0.102: F_PANEL.4 11.33,8.84 11.33,9.6 10.08,10.85 8.32,10.85 R754.2 6.67,10.03 Q39.C
GPD10_DIS_ME: length 162.2
  TOP w0.089: PCH1.BA13 56.5,44.97 v3(56.85,45.31)
  TOP w0.102: v1(38.76,26.85) 38.46,26.54 38.46,25.81 37.46,24.82 37.16,24.82 36.98,24.64 36.98,23.11 36.91,23.03 36.91,20.38 35.48,18.96 35.48,17.58 34.74,16.84 30.58,16.84 30.2,16.46 v1(29.06,16.46) ; R359.2 R360.1 7.85,104.87 7.85,104.14 8.15,103.84 8.15,94.72 15.65,87.22 17.35,87.22 23.72,80.85 23.72,75.64 15.47,67.39 15.47,54.18 15.19,53.9 v1(13.36,53.9)
  BOTTOM w0.089: 53.49,36.32 55.42,38.25 55.42,38.3 55.94,38.82 55.94,42.79 56.13,42.98 56.13,44.6 v3(56.85,45.31)
  BOTTOM w0.102: v1(13.36,53.9) 13.69,53.9 14.81,52.78 14.81,50.65 19.3,46.15 19.3,31.55 20.29,30.56 20.29,29.47 21.06,28.71 21.06,27.34 20.75,27.03 20.75,24.43 26.63,18.55 27.95,18.55 28.35,18.16 28.35,17.18 28.99,16.54 v1(29.06,16.46) ; v1(38.76,26.85) 39.14,26.85 v2(39.75,26.24) 39.93,26.06 43.26,26.06 43.71,25.6 44.87,25.6 45.4,26.14 46.53,26.14 49.91,29.51 51.49,29.51 52.26,30.29 52.48,30.29 52.93,30.75 52.93,34.26 53.26,34.59 53.26,36.09 53.49,36.32
GPP_B5: length 7.3
  TOP w0.089: PCH1.BC24 61.73,43.47 61.73,43.11 61.8,43.05 61.8,38.86 61.34,38.4 61.34,37.57 61.44,37.47
  TOP w0.102: 61.44,37.47 R607.2
GPP_B7: length 23.5
  TOP w0.089: v3(62.76,47.43) PCH1.AT24
  TOP w0.102: v1(68.83,29.51) 68.88,29.46 R674.2
  BOTTOM w0.089: 64.57,36.32 64.57,39.42 63.45,40.54 63.45,41.3 64.21,42.06 64.21,42.49 63.47,43.23 63.47,44.45 63.2,44.73 63.2,46.99 v3(62.76,47.43)
  BOTTOM w0.102: v1(68.83,29.51) v2(67.82,29.51) 67.64,29.51 66.32,30.84 66.32,33.88 65.66,34.54 65.07,34.54 64.57,35.05 64.57,36.32
GPP_B9: length 11.7
  TOP w0.089: PCH1.BB24 62.08,44.18 62.29,43.97 62.29,43.59 62.18,43.48 62.18,38.66 61.75,38.23 61.75,37.85
  TOP w0.102: 61.75,37.85 62.15,37.44 62.15,33.74 R627.2
GPP_B10: length 264.8
  TOP w0.089: v3(62.92,37.59) 62.59,37.26 62.59,36.96 ; 62.55,36.96 62.38,37.13 62.38,37.69 62.56,37.87 62.56,42.85 PCH1.BE25
  TOP w0.102: 62.59,36.96 R608.2 62.55,36.96 ; R426.2 31.79,180.78 v1(30.45,182.12) ; v1(26.71,17.11) 26.71,15.84 25.76,14.88 25.76,14.48 26.16,14.07 26.75,14.07 30.05,10.77 30.76,10.77 33.43,13.44 38.89,13.44 43.05,9.27 45.02,9.27 45.25,9.04 49.02,9.04 49.16,9.18 51.49,11.51 51.99,11.51 52.58,12.09 52.58,13.06 53.04,13.51 53.8,13.51 54.1,13.82 55.19,13.82 55.7,14.33 56.72,14.33 57.89,15.49 57.89,16.69 60.05,18.85 60.05,19.76 62.7,22.42 v1(62.7,26.07) ; v1(13.23,48.59) 13.41,48.59 17.45,52.63 17.45,66.5 25.81,74.86 25.81,82.18 18.39,89.59 18.39,102.61 16.64,104.37 16.64,107.37 23.06,113.79 23.06,117.42 24.54,118.9 v1(24.64,118.9)
  BOTTOM w0.089: v3(62.92,37.59) 62.59,37.59 62.23,37.24 62.23,36.32
  BOTTOM w0.102: 62.23,36.32 62.23,34.37 62.94,33.66 62.94,26.31 v1(62.7,26.07) ; v1(26.71,17.11) 26.59,17.11 21.7,22 20.88,22.81 20.74,22.96 20.73,22.96 19.56,24.13 19.56,25.7 18.21,27.05 18.21,28.42 16.71,29.91 16.71,45.48 13.93,48.26 13.56,48.26 v1(13.23,48.59) ; v1(24.64,118.9) 24.64,119.99 24.19,120.43 24.19,123.46 28.45,127.71 28.45,140.03 28.05,140.43 28.05,140.43 27.71,140.76 27.71,176.69 30.02,179 30.02,181.23 30.45,181.66 v1(30.45,182.12)
GPP_B10_R: length 4.2
  TOP w0.102: R426.1 33.38,181.73 33.63,181.48 33.63,181.03 34.14,180.52 35.89,180.52 36.01,180.39 PCIE1X.B17
GPP_B18: length 15.5
  TOP w0.089: 64.21,36.96 64.21,39.12 63.7,39.62 63.7,40.36 64.35,41.01 64.35,42.51 64.29,42.57 64.29,42.58 64.26,42.61 64.26,43.17 64.23,43.2 PCH1.BD28
  TOP w0.102: 64.21,36.96 64.21,35.05 64.8,34.47 v2(64.8,31.39) 64.8,31.14 64.17,30.51 R661.1 R660.1
GPP_C8: length 8.6
  TOP w0.089: PCH1.BA41 70.66,44.98 v3(70.55,45.46)
  BOTTOM w0.089: STP66.1 76.81,43.41 74.86,45.36 72.62,45.36 71.75,46.23 71.09,46.23 70.55,45.69 v3(70.55,45.46)
GPP_C9: length 9.7
  TOP w0.089: PCH1.AV44 77.14,46.33 79.22,44.25
  TOP w0.102: 79.22,44.25 v3(79.78,43.69)
  BOTTOM w0.102: STP67.1 80.29,43.18 v3(79.78,43.69)
GPP_C10: length 9.7
  TOP w0.089: PCH1.AV43 71.69,46.1 76.78,46.1 79.15,43.74 v3(79.15,43.69)
  BOTTOM w0.089: STP68.1 78.59,43.13 v3(79.15,43.69)
GPP_C11: length 11
  TOP w0.089: PCH1.AU44 72,46.61 77.22,46.61 78.21,45.62 78.54,45.62 79.22,44.93
  TOP w0.102: TP14.1 80.98,43.18 79.22,44.93
GPP_D0: length 1.4
  TOP w0.089: PCH1.AL39 v3(69.34,49.22)
  BOTTOM w0.089: v3(69.34,49.22) 69.34,49.96 STP53.1
GPP_D1: length 11
  TOP w0.089: PCH1.AN36 v3(67.68,48.18)
  BOTTOM w0.089: v3(67.68,48.18) 68.67,47.2 70.32,47.2 70.71,46.8 71.98,46.8 72.68,46.1 75.67,46.1 STP62.1
GPP_D2: length 12.1
  TOP w0.089: PCH1.AN38 v3(68.45,48.18)
  BOTTOM w0.089: v3(68.45,48.18) 69.08,47.54 70.26,47.54 70.82,46.99 72.06,46.99 72.7,46.35 76.02,46.35 76.53,45.85 76.91,45.85 77.8,44.96 STP63.1
GPP_D3: length 12.1
  TOP w0.089: PCH1.AN41 70.33,48.53 v3(69.97,48.18)
  BOTTOM w0.089: v3(69.97,48.18) 70.97,47.18 72.14,47.18 72.71,46.61 76.07,46.61 76.58,46.1 79.48,46.1
  BOTTOM w0.102: STP60.1 79.73,46.1 79.48,46.1
GPP_D21: length 7.3
  TOP w0.089: PCH1.AG44 72.12,51.84
  TOP w0.102: 72.12,51.84 72.16,51.87 72.65,51.87 73.9,50.62 77.04,50.62 v3(77.34,50.32)
  BOTTOM w0.089: v3(77.34,50.32) 77.57,50.55 STP51.1
GPP_D22: length 8.7
  TOP w0.089: PCH1.AH43 71.44,51.35 71.66,51.57 72.14,51.57 72.24,51.68 72.57,51.68 73.86,50.39 76.66,50.39
  TOP w0.102: 76.66,50.39 77.65,49.4 v3(78,49.4)
  BOTTOM w0.089: STP54.1 78.59,48.82 v3(78,49.4)
GPP_E1: length 23.4
  TOP w0.089: 78.03,46.89 78.08,46.84 79.22,46.84 ; v3(67.1,51.49) PCH1.AG35
  TOP w0.102: 78.03,46.89 75.82,49.1 74.75,49.1 v1(73.96,49.89) ; 79.22,46.84 79.68,46.84 80.73,45.78 81.29,45.78 84.18,42.9 84.18,41.76 R579.1
  BOTTOM w0.089: v1(73.96,49.89) 73.96,50.24 73.48,50.72 71.86,50.72 71.59,50.99 67.6,50.99 v3(67.1,51.49)
GPP_E2: length 22.9
  TOP w0.089: v3(76.81,49.28) 78.63,47.46 79.22,47.46 ; v3(69.39,51.49) PCH1.AG39
  TOP w0.102: 79.22,47.46 79.79,47.46 80.9,46.35 81.38,46.35 84.38,43.36 85.45,43.36 85.65,43.56 86.18,43.56 86.92,42.82 R565.1
  BOTTOM w0.089: v3(69.39,51.49) 69.81,51.92 69.97,51.92 70.33,51.92 70.79,51.45 71.81,51.45 72.14,51.13 75.26,51.13 76.1,50.29 76.1,49.76 76.58,49.28 v3(76.81,49.28)
GPP_E9: length 19.1
  TOP w0.089: PCH1.AD43 71.58,53.11 71.82,52.88 72.11,52.88 72.16,52.92 73.02,52.92 74.2,51.74 77.65,51.74
  TOP w0.102: 77.65,51.74 77.83,51.74 80.16,49.4 81.16,49.4 83.47,47.09 85.62,47.09 86.33,46.38 v2(86.33,46.15) 86.87,45.62 R549.1
GPP_E10: length 15.7
  TOP w0.089: PCH1.AD42 71.19,53.24 71.3,53.35 72.11,53.35 72.16,53.3 75,53.3 75.13,53.43 76.05,53.43
  TOP w0.102: R509.1 84.83,50.72 83.03,50.72 81.97,51.79 79.98,51.79 78.33,53.43 76.05,53.43
GPP_F0: length 25.3
  TOP w0.089: 79.22,52.17 78.18,53.21 75.41,53.21 74.85,52.65 v3(74.85,52.63) ; v3(67.1,52.53) PCH1.AD35
  TOP w0.102: R535.1 86.62,48.39 86.62,50.29 v2(86.21,50.7) 86,50.5 82.93,50.5 81.86,51.56 79.83,51.56 79.22,52.17
  BOTTOM w0.089: v3(74.85,52.63) 74.08,53.4 67.97,53.4 v3(67.1,52.53)
GPP_F1: length 22.2
  TOP w0.089: v3(65.76,53.59) 65.76,53.44 PCH1.AD31
  TOP w0.102: v3(75.69,52.58) 75.9,52.78 77.88,52.78 79.55,51.1 81.64,51.1 82.4,50.34 82.4,49.69 R534.1
  BOTTOM w0.089: v3(75.69,52.58) 74.68,53.59 v2(66.73,53.59) v3(65.76,53.59)
GPP_F2: length 20.1
  TOP w0.089: 75.83,53.01 75.51,53.01 75.29,52.78 75.29,52.4 75.11,52.22 74.6,52.22 v3(74.19,52.63) ; v3(68.63,52.53) PCH1.AD38
  TOP w0.102: R530.1 R515.1 83.49,50.04 v2(83.29,49.83) 83.26,49.83 81.76,51.33 79.68,51.33 78,53.01 75.83,53.01
  BOTTOM w0.089: v3(68.63,52.53) 69.31,53.21 73.61,53.21 v3(74.19,52.63)
GPP_F3: length 16
  TOP w0.089: PCH1.AC43 71.42,53.63 71.66,53.86 72.13,53.86 72.25,53.98 74.73,53.98 75.3,54.55 76.04,54.55
  TOP w0.102: R503.1 83.92,52.32 83.08,53.16 83.08,54.69 82.25,55.52 77.01,55.52 76.04,54.55
GPP_F4: length 19.2
  TOP w0.089: 76.1,54.93 75.91,54.74 75.22,54.74 74.64,54.17 72.17,54.17 72.11,54.11 PCH1.AB44
  TOP w0.102: R504.1 87.73,52.81 83.87,52.81 83.36,53.31 83.36,54.76 82.35,55.78 76.94,55.78 76.1,54.93
GPP_F5: length 12.8
  TOP w0.089: v3(77.37,54.1) 78.84,54.1 79.22,54.48 ; v3(70.15,54.91) PCH1.AB41
  TOP w0.102: R478.1 79.35,54.61 79.22,54.48
  BOTTOM w0.089: v3(70.15,54.91) 70.51,55.27 74.24,55.27 74.93,54.58 76.89,54.58 v3(77.37,54.1) 78.18,53.29 v2(78.18,53.11)
GPP_F10: length 27.5
  TOP w0.089: v3(66.34,54.91) PCH1.AB33
  TOP w0.102: R531.2 R516.1 87.26,50.46 86.11,51.61 83.85,51.61 82.62,52.83 82.62,54.43 82.02,55.04 77.67,55.04 v3(76.73,54.1)
  BOTTOM w0.089: v3(76.73,54.1) 76.73,53.72 v2(76.33,53.31) 75.23,53.31 74.77,53.78 67.47,53.78 v3(66.34,54.91)
GPP_F11: length 24.5
  TOP w0.089: v3(67.1,54.91) PCH1.AB35 ; 76.23,54.23 v3(76.1,54.1)
  TOP w0.102: 76.23,54.23 77.29,55.3 82.09,55.3 82.85,54.53 82.85,52.98 84,51.84 86.23,51.84 86.89,51.18 R510.2
  BOTTOM w0.089: v3(76.1,54.1) 75.72,53.72 75.11,53.72 74.85,53.97 68.04,53.97 v3(67.1,54.91)
GPP_F12: length 18.6
  TOP w0.089: 76.71,56.24 75.79,55.31 74.95,55.31 74.4,54.77 PCH1.AA45
  TOP w0.102: 76.71,56.24 77.29,56.82 82.12,56.82 83.31,55.63 83.31,55.3 83.62,54.99 83.62,53.44 84.02,53.04 86.82,53.04 R496.2
GPP_F13: length 15.7
  TOP w0.089: 76.62,56.46 75.66,55.51 74.86,55.51 74.36,55 72.24,55 72,54.77 PCH1.AA44
  TOP w0.102: 76.62,56.46 77.2,57.05 82.22,57.05 83.55,55.71 83.55,55.44 84.33,54.65 R479.2 R495.1
GPP_F15: length 18.4
  TOP w0.089: 76.5,56.72 75.48,55.7 74.77,55.7 74.27,55.19 72.16,55.19 72.11,55.15 71.75,55.15 71.52,55.38 PCH1.Y43
  TOP w0.102: 76.5,56.72 80.06,60.27 82.73,60.27 83.21,60.76 86.82,60.76 R449.1
GPP_F16: length 174.9
  TOP w0.089: 79.22,56.26 v1(78.31,56.26) ; v3(70.15,55.95) PCH1.Y41
  TOP w0.102: v1(84.45,10.85) 84.56,10.95 v1(84.56,13.11) ; v1(14.63,55.83) 14.96,56.16 R481.1 ; R461.1 79.22,56.26
  BOTTOM w0.089: v1(78.31,56.26) 79.48,56.26 ; 78.21,56.16 77.83,55.78 ; 76.94,55.78 70.32,55.78 v3(70.15,55.95)
  BOTTOM w0.102: v1(84.56,13.11) 84.84,13.39 84.84,27.69 85.7,28.55 85.7,36.86 85.12,37.44 85.12,40.89 87.53,43.31 87.53,45.24 86.77,46 86.77,56.92 86.06,57.63 81.46,57.63 80.09,56.26 79.48,56.26 ; v1(78.31,56.26) 78.21,56.16 ; v1(14.63,55.83) 13.89,55.09 13.89,54.08 15.06,52.91 15.06,50.75 19.56,46.25 19.56,31.62 20.52,30.66 20.52,29.57 21.29,28.8 21.29,27.24 20.98,26.94 20.98,24.55 22.81,22.72 22.81,22.71 26.49,19.02 29.11,19.02 29.9,19.81 33.22,19.81 33.48,20.07 40.92,20.07 41.71,19.28 45.87,19.28 51.38,13.77 57.78,13.77 57.86,13.84 73,13.84 75.95,10.9 77.06,10.9 77.8,10.16 80.95,10.16 81.48,10.69 v2(82.09,10.69) 84.3,10.69 v1(84.45,10.85) ; 77.83,55.78 76.94,55.78
GPP_G0: length 16.6
  TOP w0.089: 79.22,61.47 77.67,61.47 77.01,60.81 77.01,59.33 75.27,57.59 74.63,57.59 73.66,56.62 71.85,56.62 71.71,56.48 PCH1.U43
  TOP w0.102: 79.22,61.47 82.17,61.47 83.82,63.12 R442.2
GPP_G1: length 20.3
  TOP w0.089: 79.22,61.72 77.65,61.72 76.81,60.88 76.81,59.4 75.19,57.78 74.54,57.78 73.56,56.81 71.77,56.81 71.68,56.71 71.34,56.71 71.13,56.5 PCH1.U42
  TOP w0.102: R443.2 86.8,63.63 83.95,63.63 82.04,61.72 79.22,61.72
GPP_G2: length 16.7
  TOP w0.089: v3(70.05,57.37) PCH1.U41
  TOP w0.102: v1(79.78,57.78) 80.29,57.28 82.37,57.28 83.9,55.75 R463.2
  BOTTOM w0.089: 76.12,58.55 72.77,58.55 72.18,57.96 70.64,57.96 70.05,57.37 v3(70.05,57.37)
  BOTTOM w0.102: v1(79.78,57.78) 79.02,58.55 76.12,58.55
GPP_G3: length 19.4
  TOP w0.089: 77.11,68.83 76,67.72 76,65.33 75.16,64.49 75.16,63.2 73.3,61.34 73.3,60.43 72.42,59.54 72.24,59.54 72.02,59.32 PCH1.M44
  TOP w0.102: R412.2 77.49,69.22 77.11,68.83
GPP_G4: length 24.2
  TOP w0.089: 79.22,58.12 v3(78.87,57.76) ; v3(67.76,57.37) PCH1.U36
  TOP w0.102: 79.22,58.12 79.58,58.47 81.99,58.47 84,56.46 85.75,56.46 86.94,55.27 87.73,55.27 R464.2
  BOTTOM w0.089: v2(77.29,57.96) 75.64,57.96 75.29,58.32 72.85,58.32 72.24,57.71 71.3,57.71 70.56,56.97 68.16,56.97 v3(67.76,57.37)
  BOTTOM w0.102: v3(78.87,57.76) 78.46,58.17 77.5,58.17 v2(77.29,57.96)
GPP_G5: length 18.5
  TOP w0.089: PCH1.P44 72.1,58.17 72.22,58.05 73.12,58.05 74.05,58.98 74.58,58.98 75.06,59.46 75.06,60.68 77.37,62.99 78.08,62.99
  TOP w0.102: 78.08,62.99 80.75,62.99 84.3,66.55 R421.2 85.01,67.1 85.01,67.29 R417.1
GPP_G6: length 15.9
  TOP w0.089: 79.22,61.98 77.62,61.98 76.61,60.96 76.61,59.49 75.13,58.01 74.49,58.01 73.53,57.04 PCH1.T45
  TOP w0.102: 79.22,61.98 81.91,61.98 84.2,64.26 R435.2
GPP_G7: length 17.2
  TOP w0.089: 79.22,62.23 77.57,62.23 76.38,61.04 76.38,59.56 75.01,58.2 74.4,58.2 73.48,57.28 72.23,57.28 72,57.04 PCH1.T44
  TOP w0.102: R429.2 83.16,64.1 83.16,63.58 81.81,62.23 79.22,62.23
GPP_G12: length 17
  TOP w0.089: v4(69.95,58.27) 69.95,58.1 PCH1.R39
  TOP w0.102: v3(80.34,59.41) 80.98,60.05 83.18,60.05 83.46,60.33 R448.1 R451.1
  BOTTOM w0.089: 79.48,59.41 79.04,59.41 78.64,59 72.59,59 72.11,58.52 70.21,58.52 v4(69.95,58.27)
  BOTTOM w0.102: 79.48,59.41 v3(80.34,59.41)
GPP_G14: length 21.9
  TOP w0.089: 78.16,62.74 77.39,62.74 75.26,60.6 75.26,59.39 74.66,58.79 74.16,58.79 73.23,57.86 72.14,57.86 72.11,57.89 71.28,57.89 71.18,57.79 PCH1.R42
  TOP w0.102: 78.16,62.74 80.87,62.74 84.18,66.04 86.67,66.04 R430.1 R436.1
GPP_G15: length 22.9
  TOP w0.089: PCH1.R41 70.41,58.38 69.95,58.83 v3(69.95,59.28)
  TOP w0.102: R452.1 R455.1 86.82,57.61 84.1,57.61 81.91,59.79 81.36,59.79 v3(80.98,59.41)
  BOTTOM w0.089: 74.32,60.38 73.18,59.23 72.54,59.23 72.06,58.75 70.48,58.75 v3(69.95,59.28)
  BOTTOM w0.102: v3(80.98,59.41) 80.98,59.77 v2(80.57,60.17) 80.37,60.38 74.32,60.38
GPP_G16_IOAC: length 416.6
  TOP w0.089: PCH1.P43 71.42,58.17 71.66,58.41 72.15,58.41 72.24,58.5 72.91,58.5 74.38,59.96 74.38,60.51 77.22,63.35 77.22,64.39 76.86,64.74 76.86,67.16 78.18,68.48 79.22,68.48
  TOP w0.102: 79.22,68.48 82.12,68.48 82.45,68.15 85.8,68.15 86.82,67.13 87.67,67.13 R422.1 90.65,66.55 92.38,64.82 v1(94.39,64.82) ; v1(91.24,10.69) 92.15,9.78 v1(92.46,9.78) ; BT1.1 49.94,188.8 v1(49.94,188.24) ; v1(10.24,91.26) 16.21,85.29 v1(17.3,85.29) ; v1(50.16,177.88) 49.66,177.37 40.54,177.37 38.51,179.4 36.09,179.4 36.09,179.37 35.28,178.56 32.94,178.56 30.1,181.41 28.4,181.41 27.71,182.09 27.18,182.09 v1(26.95,181.86) ; v1(24.49,95.22) 25.65,95.22 BT2.1
  BOTTOM w0.102: v1(92.46,9.78) 93.04,9.19 96.06,9.19 97.56,10.69 97.56,20.22 98.53,21.18 98.53,26.9 94.11,31.32 94.11,34.06 93.65,34.52 93.65,36.91 94.36,37.62 94.36,44.83 94.89,45.36 94.89,46.61 93.47,48.03 93.47,52.78 95.3,54.61 95.3,63.91 v1(94.39,64.82) ; v1(50.16,177.88) 50.34,178.05 50.34,187.83 v1(49.94,188.24) ; v1(26.95,181.86) 26.11,181.03 26.11,140.06 26.77,139.4 26.77,128.35 22.53,124.1 22.53,114.27 10.16,101.9 10.16,91.34 v1(10.24,91.26) 10.46,91.03 10.46,80.57 13.23,77.8 13.23,74.73 14.3,73.66 14.3,67.59 14.96,66.93 14.96,62.74 14.12,61.9 14.12,58.12 15.14,57.1 15.14,55.63 14.22,54.71 14.22,54.08 15.32,52.98 15.32,50.88 19.79,46.41 19.79,31.72 20.78,30.73 20.78,29.64 21.51,28.9 21.51,27.15 21.21,26.84 21.21,24.64 26.58,19.28 29.03,19.28 29.79,20.04 33.12,20.04 33.38,20.29 41.02,20.29 41.81,19.51 45.97,19.51 51.43,14.05 53.82,14.05 v2(54.41,14.63) 54.41,15.14 54.89,15.62 55.42,15.62 56.24,14.81 73.58,14.81 76.48,11.91 77.47,11.91 78.26,11.13 80.09,11.13 81.1,12.14 85.06,12.14 86.18,13.26 89.15,13.26 91.24,11.18 v1(91.24,10.69) ; v1(24.49,95.22) 24.76,94.95 24.76,89.66 20.4,85.29 v1(17.3,85.29)
GPP_G18: length 23
  TOP w0.089: 79.22,68.73 78.1,68.73 76.66,67.28 76.66,64.31 75.77,63.42 75.77,62.89 73.96,61.09 73.96,60.12 72.72,58.88 71.84,58.88 71.71,58.75 PCH1.N43
  TOP w0.102: R418.1 86.62,68.38 82.6,68.38 82.25,68.73 79.22,68.73
GPP_G20: length 20
  TOP w0.089: v3(67.76,58.22) PCH1.R35
  TOP w0.102: v3(82.91,59.46) 84.33,58.04 R454.1
  BOTTOM w0.089: v3(67.76,58.22) 67.77,58.22 69.24,59.69 70.13,59.69 70.87,58.95 71.81,58.95 72.31,59.46 73.07,59.46 74.34,60.73
  BOTTOM w0.102: v3(82.91,59.46) 82.91,59.64 v2(82.32,60.22) 81.81,60.73 74.34,60.73
GPP_G21: length 19.8
  TOP w0.089: v3(78.21,57.76) 79.2,58.75 79.22,58.75 ; PCH1.U35 67.36,56.77 v3(67.1,57.27)
  TOP w0.102: R458.1 84.07,56.9 82.22,58.75 79.22,58.75
  BOTTOM w0.089: v3(78.21,57.76) 77.83,57.38 74.6,57.38 v2(74.5,57.48) 72.31,57.48 71.54,56.71 70.97,56.71 70.89,56.78 67.59,56.78 v3(67.1,57.27)
GPP_G22: length 19.5
  TOP w0.089: 75.56,65.53 74.73,64.69 74.73,63.35 72.87,61.49 72.87,60.68 72.12,59.93 PCH1.L44
  TOP w0.102: 75.56,65.53 75.56,68 77.29,69.72 83.46,69.72 84.1,70.36 R406.1
GPP_G23: length 23.1
  TOP w0.089: PCH1.L43 71.59,59.93 71.81,59.71 72.14,59.71 72.16,59.73 72.33,59.73 73.1,60.5 73.1,61.43 74.93,63.25 74.93,64.57 75.79,65.43 75.79,65.76
  TOP w0.102: R407.1 86.8,69.85 84.2,69.85 83.82,69.47 77.42,69.47 75.79,67.84 75.79,65.76
GPP_H0: length 20.4
  TOP w0.089: PCH1.AT33 66.25,46.91 66.24,46.91 v3(66.12,46.79)
  TOP w0.102: v1(77.83,35.08) 78.08,34.82 R632.2
  BOTTOM w0.089: 75.01,39.09 71.88,39.09 69.27,41.7 69.27,42.64 68.45,43.46 68.45,43.71 66.75,45.42 66.75,46.15 v3(66.12,46.79)
  BOTTOM w0.102: 75.01,39.09 75.82,39.09 77.44,37.47 v2(77.44,35.81) 77.44,35.46 v1(77.83,35.08)
GPP_H1: length 26.8
  TOP w0.089: v3(66.12,47.62) 65.95,47.62 PCH1.AR31
  TOP w0.102: v1(78.64,35.1) 78.64,31.2 R656.2
  BOTTOM w0.089: v3(66.12,47.62) 66.8,47.62 v2(66.88,47.55) 67.18,47.24 67.18,45.57 68.94,43.81 68.94,43.54 69.67,42.8 69.67,42.11 72.16,39.62 76.91,39.62
  BOTTOM w0.102: 76.91,39.62 79.35,37.19 79.35,35.81 v1(78.64,35.1)
GPP_H2: length 263.3
  TOP w0.089: PCH1.BD32 66.02,43.19 65.76,42.93 65.76,41.88 68.01,39.64 68.81,39.64 70.46,37.99 70.46,36.96
  TOP w0.102: v1(70.84,28.63) 71.01,28.8 R676.1 71.73,28.96 v2(71.04,29.64) 70.76,29.92 70.76,36.45 70.46,36.75 70.46,36.96 ; v1(37.39,21.87) 37.39,20.47 35.76,18.85 35.76,17.42 34.24,15.9 28.75,15.9 v1(28.19,16.46) ; R432.2 11.4,166.57 12.85,165.13 12.85,108.59 11.61,107.34 11.61,91.6 15.75,87.45 17.44,87.45 23.95,80.94 23.95,75.55 15.75,67.34 15.75,54.13 14.96,53.34 13.69,53.34 13.41,53.06 v1(13.33,53.06) ; v1(67.56,15.88) 67.74,16.05 67.74,27.66 68,27.91 v1(68,28.14)
  BOTTOM w0.102: v1(70.84,28.63) 68.48,28.63 v1(68,28.14) ; v1(28.19,16.46) 27.94,16.71 27.94,17.6 27.25,18.29 26.58,18.29 20.4,24.47 20.4,26.86 19.81,27.45 19.81,30.38 18.85,31.35 18.85,34.72 18.29,35.27 18.29,46.1 14.12,50.27 14.12,51.94 13.33,52.72 v1(13.33,53.06) ; v1(67.56,15.88) 67.54,15.85 57.61,15.85 56.59,16.87 53.34,16.87 51.99,15.52 51.64,15.52 46.46,20.7 42.39,20.7 41.48,21.62 37.64,21.62 v1(37.39,21.87)
GPP_H2_R: length 74.2
  TOP w0.102: PCIE16X.B31 13,166.4 12.14,167.26 12.14,179.5 11.46,180.18 R432.1 11.62,180.4 PCIE16X.B17
  BOTTOM w0.102: PCIE16X.B81 15.16,117.41 15.16,148.31 14.18,149.3 PCIE16X.B48 15.16,150.38 15.16,165.35 16.18,166.37 PCIE16X.B31
GPP_H3: length 19.2
  TOP w0.089: PCH1.BC32 66.02,43.86 66.27,43.61 66.27,43.13 66.52,42.88 66.52,42.56 66.61,42.48 66.61,41.32
  TOP w0.102: R677.2 72.87,29.82 v2(72.77,29.92) 72.64,30.05 71.48,30.05 70.99,30.53 70.99,37.82 68.94,39.87 68.05,39.87 66.61,41.32
GPP_H4: length 18.5
  TOP w0.089: PCH1.BB31 65.76,44.19 65.76,43.21 65.56,43 65.56,41.78 67.92,39.42 68.63,39.42 70.21,37.85 70.21,36.96
  TOP w0.102: R675.2 70.36,29.2 70.36,32.59 v2(70.18,32.77) 70.54,33.12 70.54,36.32 70.21,36.65 70.21,36.96
GPP_H5: length 9.8
  TOP w0.089: 71.73,36.96 71.73,38.18 70.54,39.37 70.23,39.37 69.06,40.54 68,40.54 66.99,41.55 66.99,42.64 66.93,42.7 66.93,43.28 66.6,43.61 PCH1.BC33
  TOP w0.102: R612.2 71.73,36.96
GPP_H6: length 20.3
  TOP w0.089: PCH1.BA33 66.44,44.94 v3(66.14,45.24)
  TOP w0.102: R653.2 74.8,32.25 v1(74.8,32.36)
  BOTTOM w0.089: 75.62,36.32 75.62,36.98 74.09,38.51 71.73,38.51 67.87,42.37 67.87,42.72 66.85,43.74 66.85,44.55 66.17,45.24 v3(66.14,45.24)
  BOTTOM w0.102: v1(74.8,32.36) 75.62,33.17 v2(75.62,33.5) 75.62,36.32
GPP_H7: length 21.2
  TOP w0.089: v3(66.14,46.02) 66.47,45.7 PCH1.AW33
  TOP w0.102: R655.2 77.06,31.72 v1(77.06,33.96)
  BOTTOM w0.089: 73.23,38.79 71.78,38.79 68.15,42.42 68.15,43.21 v2(67.89,43.46) 67.89,43.97 66.55,45.31 66.55,45.62 v3(66.14,46.02)
  BOTTOM w0.102: 73.23,38.79 74.55,38.79 76.07,37.26 76.07,34.95 v1(77.06,33.96)
GPP_H8: length 20.8
  TOP w0.089: v3(66.16,44.53) 66.5,44.53 66.63,44.4 PCH1.BB33
  TOP w0.102: v1(71.73,32.33) R652.2
  BOTTOM w0.089: v3(66.16,44.53) 66.66,44.06 66.66,43.66 67.42,42.91 67.68,42.64 67.68,42.15 72.09,37.74 72.09,37.34 72.54,36.88 74.6,36.88 75.16,36.32
  BOTTOM w0.102: v1(71.73,32.33) v2(72.64,32.33) 73.1,32.33 75.23,34.47 75.23,36.25 75.16,36.32
GPP_H9: length 12.6
  TOP w0.089: 67.93,40.32 66.8,41.46 66.8,42.56 66.73,42.63 66.73,43.07 PCH1.BD33
  TOP w0.102: 67.93,40.32 68.12,40.13 68.97,40.13 71.25,37.85 71.25,33.79 R629.2
GPP_H10: length 10.1
  TOP w0.089: PCH1.BD34 67.16,43.29 67.4,43.05 67.4,42.55 67.4,41.8 68.15,41.05 69.16,41.05 70.33,39.88 70.69,39.88 72.54,38.02 v1(72.54,37.67)
  BOTTOM w0.089: v1(72.54,37.67) 73.46,37.67 STP73.1
GPP_H11: length 14.6
  TOP w0.089: v3(67.97,46.16) PCH1.AW35
  BOTTOM w0.089: 79.48,44.35 76.66,44.35 75.16,45.85 72.67,45.85 71.9,46.61 70.61,46.61 70.45,46.77 68.34,46.77 67.97,46.41 v3(67.97,46.16)
  BOTTOM w0.102: 79.48,44.35 79.76,44.35 STP64.1
GPP_H12: length 12.8
  TOP w0.089: 74.02,36.96 74.02,37.13 70.76,40.39 70.47,40.39 69.33,41.53 68.37,41.53 67.78,42.12 PCH1.BD35
  TOP w0.102: R630.1 74.57,34.69 74.57,36.27 74.02,36.83 R614.1 74.02,36.96
GPP_H13: length 10.1
  TOP w0.089: 72.9,36.96 73.08,37.13 73.08,37.8 70.74,40.13 70.41,40.13 69.27,41.28 68.3,41.28 67.59,41.99 67.59,43.13 67.55,43.18 67.55,43.47 67.78,43.7 PCH1.BC35
  TOP w0.102: R613.1 72.9,36.96
GPP_H14: length 25.2
  TOP w0.089: PCH1.BA35 v3(68.35,45.2)
  TOP w0.102: R635.1 81.03,34.26 80.24,35.05 v1(80.24,35.71) 80.37,35.59 84.33,35.59 A1.1
  BOTTOM w0.089: v3(68.35,45.2) 68.7,45.2 69.07,44.83 70.16,44.83 70.84,44.15 70.84,43.43 72.61,41.67 73.52,41.67 74.02,42.16 75.36,42.16 79.48,38.05
  BOTTOM w0.102: v1(80.24,35.71) 80.24,37.29 79.48,38.05
GPP_H15: length 31
  TOP w0.089: 74.45,36.96 74.45,37.16 73.96,37.64 73.79,37.64 70.79,40.64 70.51,40.64 69.37,41.78 68.43,41.78 67.98,42.23 67.98,43.15 68,43.17 68,44.04 67.91,44.14 PCH1.BB36
  TOP w0.102: v1(80.95,35.05) 86.97,35.05 A2.1 ; R654.1 75.82,31.87 v1(75.82,32.51) 75.54,32.51 74.83,33.22 74.83,36.4 74.45,36.78 74.45,36.96
  BOTTOM w0.102: v1(80.95,35.05) 80.95,34.37 79.91,33.32 77.93,33.32 77.11,32.51 v1(75.82,32.51)
GPP_H16: length 11.3
  TOP w0.089: PCH1.BD39 69.51,43.34 69.72,43.13 69.72,42.31 70.63,41.4 70.92,41.4 74.02,38.3 74.22,38.3 75.3,37.22 75.3,37.02 75.36,36.96 ; 76.94,36.96 RJ5.2
  TOP w0.102: 76.94,36.96 76.71,36.73 75.59,36.73 75.36,36.96
GPP_H17: length 13.2
  TOP w0.089: 70.59,39.62 70.31,39.62 69.16,40.77 68.05,40.77 67.18,41.64 67.18,42.89 PCH1.BE34
  TOP w0.102: RJ7.2 72.26,33.5 72.26,37.06 72.06,37.26 72.06,38.15 70.59,39.62
GPP_H18: length 12.8
  TOP w0.089: 75.03,36.96 75.03,37.19 74.14,38.07 73.91,38.07 70.84,41.15 70.61,41.15 68.83,42.93 68.78,42.93 68.57,43.14 68.57,43.6 68.29,43.87 PCH1.BC36
  TOP w0.102: RJ6.2 76.94,36.27 76.73,36.47 75.51,36.47 75.03,36.96
GPP_H23: length 15
  TOP w0.089: 74.75,36.96 74.75,37.13 74.02,37.87 73.84,37.87 70.82,40.89 70.59,40.89 69.49,41.99 68.61,41.99 68.17,42.42 68.17,43.05 68.29,43.17 PCH1.BD36
  TOP w0.102: v2(76.5,33.31) R631.1 75.06,33.79 75.06,36.53 74.75,36.83 74.75,36.96
GSPI1_MOSI: length 26
  TOP w0.089: PCH1.AT29 64.8,47.17 v3(65.15,47.52)
  TOP w0.102: R657.1 79.73,32.1 79.73,33.75 R633.1 79.22,35.71 v1(78.87,36.07)
  BOTTOM w0.089: 68.68,43.79 66.98,45.49 66.98,46.61 66.37,47.22 65.46,47.22 v3(65.15,47.52)
  BOTTOM w0.102: v1(78.87,36.07) 78.87,36.8 v2(78.18,37.49) 76.33,39.34 72.04,39.34 69.47,41.91 69.47,42.72 68.68,43.51 68.68,43.79
H_CATERR_L: length 4.9
  TOP w0.102: CPU1.D13 114.96,162.66 114.96,162.03 114.68,161.75 v5(114.04,161.75)
  BOTTOM w0.102: STP24.1 114.1,163.4 114.48,163.02 114.48,162.18 v5(114.04,161.75)
H_PECI: length 61.2
  TOP w0.102: v1(65.58,176.2) 65.87,176.2 R270.1 R267.1 ; v5(110.39,159.92) CPU1.G7
  BOTTOM w0.102: v5(110.39,159.92) 109.93,160.37 109.93,162.05 110.06,162.18 110.57,162.18 111.22,162.84 111.22,164.87 110.59,165.51 110.59,167.41 109.85,168.15 109.85,168.38 107.85,170.38 100.63,170.38 97.33,173.69 76.05,173.69 74.12,175.62 70.69,175.62 69.19,177.11 v2(66.6,177.11) 66.5,177.11 v1(65.58,176.2)
H_PRDY_L: length 257.2
  TOP w0.102: v1(29.97,20.78) 29.97,21.11 31.11,22.25 31.11,23.5 33.05,25.43 33.05,36.89 33.4,37.24 33.4,38.96 33.12,39.24 33.12,41.04 34.55,42.47 36.02,42.47 R569.2 ; CPU1.B10 112.67,165.18 109.85,168 100.13,168 97.79,170.33 83.08,170.33 67.01,154.25 67.01,144.48 60.4,137.87 55.78,137.87 55.14,137.24 49.71,137.24 40.01,127.53 34.34,127.53 32.33,125.53 32.33,122.73 v1(32.08,122.48)
  BOTTOM w0.102: v1(32.08,122.48) 31.6,122.48 28.96,119.84 28.96,117.77 12.34,101.16 12.34,83.57 16.15,79.76 16.15,68.67 16.38,68.44 16.38,68.43 16.94,67.87 16.94,51.55 21.44,47.06 21.44,32.84 22.91,31.37 22.91,30.29 23.19,30.01 23.19,29.94 23.19,27.76 22.25,26.82 v2(22.25,26.06) 23.44,24.87 23.44,23.48 26.91,20.02 28.07,20.02 28.83,20.78 v1(29.97,20.78)
H_PREQ_L: length 264.9
  TOP w0.102: CPU1.B9 112.15,164.55 112.81,164.55 113.02,164.75 113.02,165.14 109.96,168.2 100.25,168.2 97.87,170.59 82.52,170.59 81.86,169.93 R276.2 73.98,161.59 66.78,154.38 66.78,144.58 60.3,138.1 55.68,138.1 55.04,137.46 49.62,137.46 39.94,127.79 34.26,127.79 32.08,125.6 32.08,123.42 v1(31.85,123.19) ; R583.2 35.89,40.89 35.51,41.28 33.68,41.28 33.35,40.95 33.35,39.4 33.63,39.12 33.63,37.15 33.27,36.79 33.27,25.32 31.34,23.39 31.34,21.41 v1(30.71,20.78)
  BOTTOM w0.102: v1(30.71,20.78) 30.23,20.29 29.49,20.29 29.44,20.35 28.73,20.35 28.12,19.74 26.77,19.74 22.86,23.65 v2(22.86,24.41) 21.67,25.6 21.67,26.57 22.96,27.86 22.96,29.91 22.68,30.19 22.68,31.27 21.21,32.75 21.21,46.96 16.71,51.46 16.71,67.72 15.93,68.5 15.93,79.63 12.12,83.44 12.12,101.27 28.73,117.88 28.73,120.07 v1(31.85,123.19)
H_SKTOCC_L: length 385.8
  TOP w0.089: 77.8,58.34 75.34,55.89 74.68,55.89 74.18,55.38 PCH1.Y44
  TOP w0.102: v1(102.03,60.1) 99.57,60.1 98.53,61.14 92.68,61.14 91.87,60.33 91.03,60.33 90.37,60.99 83.11,60.99 82.63,60.5 79.96,60.5 77.8,58.34 ; v1(182.68,127.2) 182.06,127.2 QN13.1 181.7,125.97 182.32,125.35 R316.2 ; CPU1.AB35 v5(137.27,146.2) ; Q11.2 156.06,199.9 155.88,199.72 155.88,199.21 156.21,198.88 161.29,198.88 162.61,197.56 172.92,197.56 173.27,197.92 176.66,197.92 179.96,201.22 181.13,201.22 183.67,203.76 196.52,203.76 197.92,202.36 197.92,190.65 198.73,189.84 198.73,127.13 197.56,125.96 v1(197.13,125.96) ; v1(165.35,70.33) 165.1,70.59 163.8,70.59 162.86,69.65 159.54,69.65 v1(158.57,68.68)
  BOTTOM w0.102: v1(102.03,60.1) 102.26,60.33 109.04,60.33 111.68,62.97 111.68,67.01 113.95,69.27 134.59,69.27 143.08,60.78 152.35,60.78 154.66,63.09 157.61,63.09 158.57,64.06 v1(158.57,68.68) ; v1(165.35,70.33) 165.43,70.33 165.94,70.84 173.99,70.84 182.98,79.83 182.98,101.45 181.33,103.1 181.33,120.98 v2(183.01,122.66) 183.51,123.16 183.51,126.37 v1(182.68,127.2) 181.85,128.03 181.85,128.99 ; 181.85,128.99 181.15,129.69 176.17,129.69 157.15,148.72 143.3,148.72 142.16,147.57 138.65,147.57 v5(137.27,146.2) ; 181.85,128.99 182.52,129.67 186.28,129.67 187.78,128.17 194.64,128.17 196.85,125.96 v1(197.13,125.96)
H_TCK: length 53.4
  TOP w0.102: CPU1.F11 v5(114.04,160.83) ; v1(77.67,176.3) 76.94,176.3 75.31,177.93 R266.1 R269.1
  BOTTOM w0.102: v5(114.04,160.83) 114.68,161.47 114.68,163.47 114.15,164.01 113.66,164.01 111.68,165.99 111.68,167.97 111.18,168.48 111.18,169.95 108.94,172.19 101.58,172.19 98.2,175.56 78.41,175.56 v1(77.67,176.3)
H_TDI: length 51.5
  TOP w0.102: R271.1 75.39,175.64 v1(75.87,176.12) ; v5(114.04,159.92) CPU1.G12
  BOTTOM w0.102: v1(75.87,176.12) 76.2,175.79 77.11,175.79 77.72,175.18 98.04,175.18 101.4,171.83 108.79,171.83 110.82,169.8 110.82,168.53 111.46,167.89 111.46,165.89 112.9,164.44 112.9,163.14 113.61,162.44 113.61,160.58 114.04,160.15 v5(114.04,159.92)
H_TDO: length 58.6
  TOP w0.102: v1(73.94,179.58) 71.95,179.58 R263.1 R265.2 ; v5(114.96,159.92) CPU1.H13
  BOTTOM w0.089: 111.89,169.55 111.89,168.5 113.03,167.36
  BOTTOM w0.102: 113.03,167.36 113.03,166.4 115.11,164.32 115.11,161.59 115.42,161.29 115.42,160.6 114.96,160.14 v5(114.96,159.92) ; v1(73.94,179.58) 73.94,179.22 v2(74.4,178.77) 75.74,177.42 78.16,177.42 79.29,176.28 98.56,176.28 101.95,172.9 109.35,172.9 111.89,170.36 111.89,169.55
H_THERMTRIP_L: length 246.6
  TOP w0.102: v1(33.3,125.81) 33.3,126.14 34.44,127.28 40.08,127.28 49.81,137.01 55.24,137.01 55.88,137.64 60.5,137.64 67.23,144.37 67.23,154.09 83.2,170.05 97.74,170.05 100,167.79 109.75,167.79 111.22,166.32 111.22,163.12 111.6,162.74 113.21,162.74 CPU1.D11 ; R488.1 R487.2 36.34,54.94 32.87,54.94 32.18,54.25 32.18,53.62 27.56,49 27.56,41.71 27.79,41.48 27.79,35.69 26.57,34.47 24.97,34.47 v1(24.49,33.99)
  BOTTOM w0.102: v1(33.3,125.81) v2(33.88,125.22) 34.09,125.02 34.09,123.55 34.47,123.16 34.47,120.4 32.82,118.75 32.82,117.93 22.12,107.24 22.12,105.74 19.61,103.23 18.26,103.23 14.73,99.69 14.73,86.33 17.4,83.67 17.4,82.27 18.41,81.25 18.41,69.55 19.32,68.64 19.32,52.26 19.33,52.25 19.33,52.19 23.88,47.65 23.88,34.59 v1(24.49,33.99)
H_TMS: length 55.7
  TOP w0.102: v1(74.75,179.63) 74.17,180.21 R262.1 ; v5(115.87,161.75) CPU1.F13
  BOTTOM w0.089: 112.24,169.55 112.24,168.45 113.23,167.46
  BOTTOM w0.102: v5(115.87,161.75) 115.87,161.87 115.37,162.38 115.37,164.35 113.23,166.48 113.23,167.46 ; v1(74.75,179.63) v2(76.12,178.26) 76.58,177.8 78.28,177.8 79.43,176.66 98.69,176.66 102.09,173.25 109.52,173.25 112.24,170.54 112.24,169.55
H_TRST_L: length 268.9
  TOP w0.102: v1(29.57,30.14) 27.32,30.14 24.08,26.9 v1(24.08,26.44) ; v5(114.96,160.83) CPU1.F12 ; v1(32.84,122.78) 32.92,122.78 34.8,124.66 37.13,124.66 37.54,125.07 41.3,125.07 49.4,133.17 51.92,133.17 v1(52.2,133.45)
  BOTTOM w0.102: v1(32.84,122.78) 32.97,122.78 33.3,122.45 33.3,120.9 31.55,119.15 31.55,117.98 20.75,107.19 20.75,106.2 19.33,104.78 17.83,104.78 13.51,100.46 13.51,84.23 17.37,80.37 17.37,69.22 18.11,68.48 18.11,52.07 22.61,47.58 22.61,33.4 24.08,31.93 24.08,30.78 24.38,30.48 24.38,26.75 v1(24.08,26.44) ; v1(29.57,30.14) 29.57,33.14 30.68,34.25 30.68,38.38 33.22,40.92 33.43,40.92 SR22.2 ; v1(52.2,133.45) 52.2,134.47 51.26,135.41 51.26,166.14 61.8,176.68 62.76,176.68 65.48,179.4 v2(66.95,179.4) 72.67,179.4 75.01,177.06 77.95,177.06 79.09,175.93 98.41,175.93 101.8,172.54 109.09,172.54 111.53,170.1 111.53,168.45 111.89,168.1 111.89,166.09 112.88,165.1 114.04,165.1 114.88,164.26 114.88,160.91 v5(114.96,160.83)
H_VIDALERT_L: length 46.4
  TOP w0.102: R154.2 173.4,210.19 v1(173.79,210.19) 174.12,210.19 R155.1
  BOTTOM w0.102: v1(173.79,210.19) 173.51,210.19 171.15,207.82 170.28,207.82 168.5,206.04 167.06,206.04 163.35,202.34 163.35,201.92 161.06,199.63 161.06,194.42 149.39,182.75 v2(149.39,182.63) 149.39,179.19 SR7.2 SR11.1
H_VIDALERT_L_R: length 4.7
  TOP w0.102: U19.6 168.8,210.8 169.72,209.88 171.38,209.88 R154.1
H_VIDSCK: length 45.1
  TOP w0.102: R158.1 174.38,209.3 v1(173.71,209.3) 173.04,209.3 R157.2
  BOTTOM w0.102: SR12.1 SR8.2 150.57,179.23 v2(150.57,181.28) 150.57,183.36 161.47,194.25 161.47,199.46 163.75,201.75 163.75,202.17 167.22,205.64 168.68,205.64 170.46,207.42 171.37,207.42 173.25,209.3 v1(173.71,209.3)
H_VIDSCK_R: length 4.4
  TOP w0.102: R157.1 171.74,209.65 169.62,209.65 168.87,210.4 U19.5
H_VIDSOUT: length 48.2
  TOP w0.102: R141.2 173.55,211.07 v1(173.71,211.07) 173.87,211.07 R142.1
  BOTTOM w0.102: v1(173.71,211.07) 170.92,208.28 170.15,208.28 168.33,206.45 166.89,206.45 162.94,202.5 162.94,202.08 160.65,199.8 160.65,194.59 149.86,183.79 149.28,183.79 148.19,182.71 v2(148.19,180.91) 148.19,179.14 SR6.2 SR10.1
H_VIDSOUT_R: length 5.4
  TOP w0.102: R141.1 171.5,211.25 171.5,210.59 171.12,210.21 169.75,210.21 168.76,211.2 U19.7
HDA_BCLK_R: length 8
  TOP w0.089: v3(51.79,40.03) 51.79,40.46 53.93,42.6 53.93,44.11 54.48,44.66 PCH1.BA9
  BOTTOM w0.089: SR25.2 51.66,38.74 52.07,39.14 52.07,39.75 v3(51.79,40.03)
HDA_BITCLK: length 254.8
  TOP w0.102: v1(19.68,203.15) 19.18,203.66 19.18,207.02 R169.1 ; v1(8.43,23.19) 11.02,20.6 17.5,20.6 18.57,19.53 20.37,19.53 24.05,23.22 24.05,24.86 28.03,28.83 29.54,28.83 30.51,27.86 v1(31.22,27.86)
  BOTTOM w0.089: SR25.1 47.83,36.5 45.57,36.5
  BOTTOM w0.102: 45.57,36.5 41.63,36.5 40.92,37.21 35.63,37.21 33.12,34.7 33.12,29.26 31.73,27.86 v1(31.22,27.86) ; v1(19.68,203.15) 19.56,203.02 v2(19.56,202.26) 19.56,201.42 19.2,201.07 13.87,201.07 11.73,198.94 11.73,195.28 10.41,193.95 10.41,191.41 9.75,190.75 9.75,181.41 10.46,180.7 10.46,108.36 4.78,102.67 4.78,86.62 5.64,85.75 5.64,85.75 5.66,85.72 5.66,82.11 3.71,80.15 3.71,28.63 5.16,27.18 5.21,27.18 5.49,27.18 6.17,26.49 6.17,24.56 6.76,23.98 7.65,23.98 v1(8.43,23.19)
HDA_RST_L: length 281.2
  TOP w0.102: v1(22.86,203.84) 22.86,204.62 22.2,205.28 R168.2 22.45,207.42 24.56,205.31 38.23,205.31 39.6,206.68 40.95,206.68 R172.2 ; v1(30.91,27.05) 30.63,27.05 29.34,28.35 28.23,28.35 24.54,24.66 24.54,23.02 20.57,19.05 18.36,19.05 17.3,20.12 10.21,20.12 v1(9.91,20.42)
  BOTTOM w0.089: SR24.1 47.53,37.34 45.57,37.34
  BOTTOM w0.102: v1(22.86,203.84) v2(22.86,203) 22.86,202.67 20.47,200.28 14.38,200.28 12.47,198.37 12.47,194.92 11.2,193.65 11.2,191.16 10.46,190.42 10.46,181.81 11.2,181.08 11.2,108.01 10.49,107.29 5.49,102.29 5.49,87 6.86,85.62 6.86,67.82 4.42,65.38 4.42,29.06 5.56,27.91 6.73,27.91 9.4,25.25 9.4,21.56 9.91,21.06 v1(9.91,20.42) ; v1(30.91,27.05) 30.48,27.48 30.48,28.37 32.41,30.3 32.41,35.05 35.82,38.46 41.22,38.46 42.34,37.34 45.57,37.34
HDA_RST_L_R: length 5.7
  TOP w0.089: PCH1.BD8 54.18,42.58 52.43,40.83 v3(52.43,40.21)
  BOTTOM w0.089: SR24.2 51.02,40.07 51.43,40.49 52.15,40.49 v3(52.43,40.21)
HDA_SDIN0: length 267.6
  TOP w0.089: PCH1.BE7 53.68,42.91 53.68,42.64 51.38,40.35 51.38,39.57 v3(51.64,39.32)
  TOP w0.102: v1(31.42,28.6) 30.51,28.6 29.69,29.41 27.89,29.41 23.57,25.1 23.57,23.42 20.17,20.02 18.77,20.02 17.7,21.08 11.66,21.08 8.81,23.93 4.24,23.93 v1(4.06,23.75) ; v1(21.18,203.86) 21.18,204.01 19.66,205.54 19.66,209.71 R152.1
  BOTTOM w0.089: 45.57,37.08 47.55,37.08 49.78,39.32 v3(51.64,39.32)
  BOTTOM w0.102: v1(21.18,203.86) 21.06,203.99 19.46,203.99 v2(17.7,202.23) 17.3,201.83 13.61,201.83 11,199.21 11,195.61 9.6,194.21 9.6,191.69 9.04,191.13 9.04,181.05 9.65,180.44 9.65,108.91 4.06,103.33 4.06,86.32 4.93,85.46 4.93,82.42 2.57,80.06 2.57,25.25 v1(4.06,23.75) ; 45.57,37.08 42.21,37.08 41.07,38.23 35.92,38.23 32.64,34.95 32.64,29.82 v1(31.42,28.6)
HDA_SDO_DIS: length 183.8
  TOP w0.102: v1(8.33,14.55) 7.19,13.41 5.08,13.41 4.34,14.15 2.01,14.15 1.24,14.91 1.24,108.33 2.9,109.99 R353.2 ; v1(34.14,38.1) 34.14,35.46 34.49,35.1 34.49,30.12 35.99,28.63 38.76,28.63 39.42,27.97 39.42,26.77 38.71,26.06 38.71,23.67 38.15,23.11 38.15,20.55 37.95,20.35 37.95,17.04 36.66,15.75 34.72,15.75 34.06,15.09 v1(34.01,15.09)
  BOTTOM w0.089: SR21.1 49.4,41.45 49.4,40.16 47.27,38.02 45.57,38.02
  BOTTOM w0.102: 45.57,38.02 42.39,38.02 41.43,38.99 36.22,38.99 35.74,39.47 34.98,39.47 34.14,38.63 v1(34.14,38.1) ; v1(34.01,15.09) 33.58,15.09 31.01,12.52 24.35,12.52 23.89,12.98 21.62,12.98 21.48,12.85 20.8,12.17 11.1,12.17 10.19,13.08 9.02,13.08 8.48,13.61 v2(8.36,13.61) 8.33,13.64 v1(8.33,14.55)
HDA_SDO_DIS_R: length 7.5
  TOP w0.102: R344.1 v1(8.69,113.65) 8.69,112.45 RJ3.2 7.39,111.81 6.76,111.18 5.05,111.18 4.82,110.94 R353.1
HDA_SDO_R: length 7.3
  TOP w0.089: v3(54.18,45.14) 54.18,44.91 PCH1.BB7
  BOTTOM w0.089: v3(54.18,45.14) 54.33,44.98 54.33,43.81 v2(53.7,43.18) 53.31,42.8 52.17,42.8 51.74,43.23 SR20.2 SR21.2
HDA_SDO_R1: length 2.4
  TOP w0.102: ME_DISABLE.2 6.63,112.83 RJ3.1
HDA_SDO_R_P1: length 2.1
  TOP w0.102: ME_DISABLE.3 8.03,109.6 R356.1
HDA_SDOUT: length 274.3
  TOP w0.102: R344.2 v1(9.14,115.23) ; v1(30.2,26.31) 30.2,26.72 29.03,27.89 28.42,27.89 24.99,24.46 24.99,22.76 20.75,18.52 18.24,18.52 17.12,19.63 9.22,19.63 v1(9.12,19.74) ; v1(18.44,204.04) 18.44,206.71 17.93,207.21 17.93,211.61 17.39,212.15 CODEC.5
  BOTTOM w0.089: 45.57,38.25 47.02,38.25 49.15,40.39 49.15,41.68 49.49,42.03 49.49,42.68 SR20.1
  BOTTOM w0.102: v1(9.12,19.74) 8,18.62 3.86,18.62 2.34,20.14 2.34,80.16 4.7,82.52 4.7,85.36 3.76,86.3 3.76,103.35 9.42,109.02 9.42,114.95 v1(9.14,115.23) 9.42,115.52 9.42,180.29 8.81,180.9 8.81,191.26 9.37,191.82 9.37,194.31 10.74,195.68 10.74,199.31 13.49,202.06 16.46,202.06 v1(18.44,204.04) ; 45.57,38.25 42.52,38.25 41.53,39.24 36.3,39.24 35.84,39.7 34.87,39.7 v2(32.36,37.19) 31.95,36.78 31.95,30.51 30.02,28.58 30.02,26.49 v1(30.2,26.31)
HDA_SYNC: length 269.1
  TOP w0.102: CODEC.10 19.89,212.37 20.37,211.89 21.49,211.89 21.67,211.71 21.67,204.93 21.95,204.65 v1(21.95,203.84) ; v1(9.3,20.96) 9.3,20.24 9.68,19.86 17.22,19.86 18.33,18.76 20.66,18.76 24.76,22.86 24.76,24.56 28.32,28.12 29.16,28.12 v1(30.99,26.29)
  BOTTOM w0.089: 45.57,37.8 47.38,37.8 49.61,40.02 49.61,40.56 SR23.1
  BOTTOM w0.102: v1(9.3,20.96) 9.17,21.08 9.17,25.12 6.63,27.66 5.41,27.66 4.19,28.88 4.19,65.51 6.63,67.94 6.63,85.47 5.26,86.84 5.26,102.39 10.32,107.45 10.95,108.08 10.95,181 10.24,181.71 10.24,190.53 10.95,191.24 10.95,193.78 12.24,195.07 12.24,198.5 14.33,200.58 19.86,200.58 v2(21.36,202.08) 21.95,202.67 v1(21.95,203.84) ; v1(30.99,26.29) 30.25,27.03 30.25,28.47 32.18,30.4 32.18,35.18 35.74,38.74 41.35,38.74 42.29,37.8 45.57,37.8
