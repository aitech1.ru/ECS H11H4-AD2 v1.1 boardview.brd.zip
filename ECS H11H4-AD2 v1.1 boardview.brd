# Allegro board ECS H11H4-AD2 v1.1 boardview.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
+5V_DUAL: length 243
  TOP w0.254: R751.1 6.9,11.66 v1(6.96,11.61) ; 169.85,68.38 170.38,67.84 170.38,45.44 166.29,41.35 166.29,33.93 164.74,32.38 164.74,27.51 165.48,26.77 165.48,8.18 163.19,5.89 131.24,5.89 130.02,7.11 v1(128.37,7.11) ; v1(26.8,3.18) 26.34,2.72 17.68,2.72 16.74,1.78 7.14,1.78 5.26,3.66 5.26,6.2 R762.1 7.19,7.62 R760.1 7.9,9.87 R754.1 7.96,9.93 v1(8.76,9.93)
  BOTTOM w0.254: v1(26.8,3.18) 29.31,0.66 124.33,0.66 128.37,4.7 v1(128.37,7.11) ; v1(8.76,9.93) 7.09,11.61 v1(6.96,11.61)
  vias: v1(141.88,65.23) v1(141.91,64.47) v1(142.65,64.54) v1(142.7,65.28) v1(149.89,79.88) v1(149.89,79.07) v1(150.95,78.59) v1(150.95,77.62) v1(152.48,76.66) v1(154.03,79.98) v1(154.38,76.66) v1(156.08,80.01) v1(158.75,79.98) v1(161.32,80.01) v1(162.84,77.62) v1(164.06,79.91) v1(164.13,77.65) v1(165.2,79.27)
+5V_DUAL_PFB: length 20.6
  TOP w0.254: v1(150.47,75.51) 150.16,75.82 R399.2
  BOTTOM w0.254: v1(150.47,75.51) 151.1,74.88 151.1,70.92 147.68,67.49 139.34,67.49 v2(139.32,67.51) 138.96,67.51 v1(138.1,68.38)
+5V_HDMI: length 33.6
  TOP w0.508: v1(143.23,225.96) 144.45,224.74 144.45,221.88 D4.3 ; v1(128.07,227.36) 128.09,227.33 U8.5 ; v1(147.55,225.96) 147.85,226.26 U11.5
  BOTTOM w0.508: v1(128.07,227.36) 129.06,227.36 SC5.1 130.45,225.96 v2(131.17,225.96) v1(143.23,225.96) SC10.1 v1(147.55,225.96) 149,225.96 151.49,228.45 v1(152.37,228.45)
+5V_HDMI0: length 13.4
  TOP w0.254: HDMI2.18 v1(128.6,231.24)
  TOP w0.508: v1(126.34,227.38) 126.29,227.33 D2.3 ; v1(128.09,224.28) 128.09,222.72 F2.2
  BOTTOM w0.508: v1(128.6,231.24) 128.6,229.64 v1(126.34,227.38) 126.34,226.97 v2(127.79,225.53) 128.09,225.22 v1(128.09,224.28)
+5VA: length 28.8
  TOP w0.254: C64.1 12.34,220.27 12.4,220.22 ; CODEC.38 12.81,219.8 12.65,219.96
  TOP w0.406: CODEC.25 20.96,222.99 21.23,223.27
  TOP w0.508: v1(10.9,222.86) 10.9,222.67 C50.1 12.01,221.56 C64.1 ; 12.65,219.96 12.4,220.22
  TOP w0.762: 21.23,223.27 22.23,224.26 C26.1 22.23,227.74 C17.1 21.54,228.88 v1(20.09,228.88)
  BOTTOM w0.762: v1(20.09,228.88) 20.52,228.45 v2(20.52,227.61) 20.52,225.73 19.15,224.36 12.4,224.36 v1(10.9,222.86)
+5VDUAL_1P0A: length 7.5
  TOP w0.635: R457.2 v1(124.43,59.89)
  BOTTOM w0.635: EC29.1 124.91,59.89 v1(124.43,59.89)
+5VSB: length 467.2
  TOP w0.254: v1(12.95,60.76) 12.55,60.35 RJ4.1 ; R425.1 C469.1 ; v1(12.65,106.81) 12.65,102.44 v1(15.62,99.47) ; v1(24.61,7.49) 24.49,7.62 24.49,9.39 R757.2 ; v1(34.9,124.05) 35.03,124.18 37.69,124.18 38.25,124.74 45.52,124.74 46.46,125.68 46.46,127.86 49.48,130.89 50.19,130.89 50.77,130.3 R306.1
  TOP w0.406: 15.52,73.31 U30.2
  TOP w0.508: Q30.D 146.53,48.49 146.53,52.48 v1(146.46,52.55) ; v1(135.94,53.64) Q29.S 137.59,54.32 C528.1 139.23,53.37 R489.1 ; v1(159.31,68.53) 159.61,68.83 162.88,68.83 163.23,68.48 R415.1 C469.1 165.8,68.48 166.34,67.94 ; 15.52,73.31 14.99,72.77 12.24,72.77 v1(12.09,72.92)
  TOP w1.016: v6(12.93,193.27) 12.93,198.68 14.57,200.32 19.55,200.32 21.29,202.06 40.36,202.06 42.77,199.64 42.77,191.26 46.41,187.63 46.41,185.75 50.39,181.76 60.58,181.76 69.44,190.63 69.44,198.37 69.8,198.02 72.21,198.02 73.3,196.93 77.65,196.93 87.45,206.73 98.35,206.73 102.11,210.49 106.22,210.49
  BOTTOM w0.254: v1(34.9,124.05) 35,123.95 35,120.17 33.35,118.52 33.35,117.7 22.66,107.01 22.66,105.46 19.74,102.54 18.69,102.54 v1(15.62,99.47)
  BOTTOM w0.508: v1(145.8,48.77) 149.3,48.77 154.56,54.03 154.56,54.76 156.67,56.87 158.52,56.87 163.09,61.44 163.09,64.77 159.33,68.53 v1(159.31,68.53) ; v1(10.85,67.87) 10.85,70.56 12.09,71.81 v1(12.09,72.92) ; v1(135.94,53.64) 143.19,53.64 144.27,52.55 v1(146.46,52.55) ; v1(134.72,6.86) 134.72,10.92 133.93,11.72 SR768.1 132.94,10.64 SR765.1
  BOTTOM w1.016: v1(18.97,13.31) v1(18.3,13.98) 16.51,15.77 15.29,15.77 12.42,18.64 12.42,21.01 10.85,22.58 v1(10.85,22.78) v1(10.85,23.93) 10.85,26.39 10.01,27.23 10.01,50.57 6.1,54.48 6.1,65.1 8.25,67.26 v1(8.25,67.89) 8.28,86.66 7.21,87.73 7.21,101.3 12.65,106.73 v1(12.65,106.81) v2(12.65,191.97) 12.65,192.99 v6(12.93,193.27)
  vias: v1(10.79,66.68) v1(145.14,48.39) v1(145.77,47.6)
+12V: length 361
  TOP w0.254: R447.1 135.46,62.69 140.41,62.69 141.5,61.59 144.04,61.59 146.66,64.21 152.83,64.21 154.33,65.71 v1(155.19,65.71) ; v1(159,75.26) 157.91,74.17 v1(157.91,70.82) 156.6,69.5 R411.1 ; R562.1 119.01,44.83 121.54,44.83 v1(121.89,44.48) ; v1(157.23,226.47) 157.23,225.89 C30.1 R50.2 ; v1(62.46,178.66) 63.63,179.83 63.63,181.86 71.4,189.64 71.4,192.1 73.53,194.23 77.8,194.23 88.47,204.9 98.78,204.9 102.79,208.92 109.19,208.92 110.01,209.73 111.1,209.73 115.06,213.69 118.19,213.69 C101.1 R125.2 120.24,216.92 121.39,218.06 125.5,218.06 125.91,218.47 125.91,219.84 126.64,220.57 129.64,220.57 130.2,221.13 v1(130.2,224.49) ; v1(131.14,39.37) 132.79,37.72 132.79,36.67 ATX_POWER.11 ; R318.1 56.29,124.54 v1(55.58,124.54)
  TOP w0.305: R741.1 47.69,13.13 v1(44.55,9.98)
  TOP w0.508: U34.8 174.64,65.21 v1(174.6,65.25) ; R501.1 174.47,51.26 v1(174.6,51.13) 175.07,50.66 D18.N 177.63,50.66 R525.1 ; v1(133.15,31.62) 131.83,31.62 R666.2 ; v1(62.46,178.66) 61.04,180.09 50.8,180.09 45.44,185.45 45.44,187.22 42.51,190.16 42.01,190.16 v1(42,190.17) ; v1(50.75,131.17) 51.03,130.89 54.81,130.89 v1(56.77,128.93) ; C379.2 56.92,115.93 56.24,116.62 56.24,117.2 v1(55.75,117.68)
  TOP w1.016: Q22.E 181.46,69.47 R420.2
  BOTTOM w0.254: v1(121.89,44.48) 121.89,43.74 122.68,42.95 124.99,42.95 128.57,39.37 v1(131.14,39.37) ; v1(50.62,2.67) 47.04,2.67 45.19,4.52 45.19,9.35 v1(44.55,9.98) ; v1(172.26,75.62) 159.36,75.62 v1(159,75.26) ; v1(157.23,226.47) 156.29,225.53 151.46,225.53 151.21,225.78 149.83,225.78 149.35,225.3 131.01,225.3 v1(130.2,224.49) ; v1(155.19,65.71) 155.19,65.99 157.91,68.71 v1(157.91,70.82)
  BOTTOM w0.508: v1(62.46,178.66) 50.37,166.57 50.37,131.55 v1(50.75,131.17) ; v1(42,190.17) 42,196.39 PCIE1X.A2 ; v1(56.77,128.93) 55.58,127.74 v1(55.58,124.54) 54.87,124.54 54.43,124.1 54.43,118.16 55.02,117.58 55.65,117.58 v1(55.75,117.68) ; v1(174.6,51.13) v1(174.6,65.25) 174.6,67.11 175.44,67.94 179.93,67.94 Q22.E
  vias: v1(1.24,183.26) v1(1.17,182.27) v1(1.24,181.28) v1(1.3,180.31) v1(30.43,2.64) v1(30.45,1.65) v1(43.05,2.87) v1(43.08,1.88) v1(133.22,33.63) v1(136.32,35.69) v1(136.35,31.37) v1(139.17,33.22) v1(139.17,31.55) v1(171.04,31.14) v1(171.04,28.55) v1(171.15,25.76) v1(171.15,23.85) v1(171.96,31.12) v1(171.96,28.52) v1(172.16,25.73) v1(172.16,23.85) v1(173.3,2.34) v1(174.47,2.34) v1(175.54,2.31) v1(176.63,2.29) v1(182.47,68.4) v1(182.5,67.13) v1(183.67,105.89) v1(184.3,103.17) v1(184.71,105.28)
+12V_4P:
  vias: v6(179.04,196.34) v6(180.95,199.01) v6(182.73,198.25) v6(183.11,196.6) v6(183.87,199.64) v6(185.52,195.96) v6(185.52,194.56) v6(187.43,200.28) v6(187.43,196.6) v6(189.71,200.28) v6(189.71,196.6) v6(192.38,200.28) v6(192.38,196.6) v6(194.49,200.25) v6(194.49,196.57)
+P1V0_PCH_VCCDSW: length 13.9
  TOP w0.203: PCH1.BA29 64.52,44.96 64.29,45.19 v3(63.83,45.19)
  BOTTOM w0.203: v3(63.83,45.19) 63.83,43.54 64.85,42.52 64.85,42.34
  BOTTOM w0.381: SC55.2 70.51,36.3 69.98,36.83 v2(69.98,37.06) 69.98,37.67 67.46,40.18 65.74,40.18 64.85,41.07 64.85,42.34
+V1P0A: length 223.6
  TOP w0.254: v3(60.3,57.28) 60.05,57.53 PCH1.R19 ; R566.1 33.38,43.25 34.04,43.91 34.04,44.36 R556.2 34.57,46.56 v1(35.69,47.68)
  TOP w0.305: R528.1 36.25,49.1 v1(37.15,48.2) 37.15,47.49 37.57,47.07 R541.1 ; PCH1.U20 60.02,56.8 v3(60.39,56.43)
  TOP w0.381: PCH1.AD15 57.76,53.13 57.25,53.64 v3(56.87,53.64) ; PCH1.AC17 v3(58.86,53.33) ; v4(58.86,55.66) PCH1.V17 ; v3(62.73,53.33) PCH1.AE26 ; PCH1.AJ20 v3(60.41,51.01) PCH1.AJ21 v3(61.18,51.01) PCH1.AJ23 v3(61.96,51.01) PCH1.AJ25 ; v3(63.51,53.33) PCH1.AC28 ; v3(63.51,54.11) PCH1.AA28 ; v3(63.51,55.66) PCH1.V26 ; C516.2 v3(44.52,57.25) ; v3(64.28,55.66) PCH1.V28 ; v3(61.96,56.43) PCH1.U23 ; PCH1.AC23 v3(61.96,53.33) PCH1.AE23 ; v3(57.89,57.4) 57.89,58.25 58.38,58.75 PCH1.N17 ; v3(61.18,56.43) PCH1.U21 ; PCH1.R17 59.07,57.34 v3(59.12,57.34) ; v3(63.51,56.43) PCH1.U26 ; PCH1.AA26 v3(62.73,54.88) PCH1.Y25 ; PCH1.U25 v3(62.73,56.43) ; v3(62.73,54.11) PCH1.AC26 ; PCH1.AA23 v3(61.96,54.88) PCH1.Y23
  TOP w0.508: v1(76.23,72.19) 75.79,71.75 R405.2 v1(76.68,70.42) ; v1(37.34,61.75) 36.78,62.31 32.59,62.31 31.39,63.5 31.39,72.49 31.27,72.62 31.27,73.69 30.78,74.17 30.78,83.95 v1(37.54,90.7) ; R289.1 69.89,152.16 68.71,150.98 68.71,143.76 61.21,136.27 57.53,136.27 57.02,135.76 50.32,135.76 40.31,125.76 35.59,125.76 v1(35.48,125.86) ; v1(22.28,99.52) 22.63,99.87 24.69,99.87 26.19,101.37 36.73,101.37 v1(37.54,100.56) ; v1(133.27,52.93) R485.1
  BOTTOM w0.508: v1(35.48,125.86) 35.59,125.76 35.59,118.87 23.42,106.71 23.42,105.16 22.28,104.01 v1(22.28,99.52) ; v1(133.27,52.93) 133.27,51.56 129.72,48.01 121.95,48.01 119.71,45.77 112.78,45.77 112.39,46.15 107.14,46.15 105.05,48.23 100.13,48.23 95.88,52.48 EC34.1 ; v1(37.54,90.7) v1(37.54,100.56) ; SC44.1 60.33,58.12 60.33,57.31 v3(60.3,57.28)
  vias: v1(38.1,61.52) v1(94.23,54.66) v1(94.79,51.31) v1(95.66,51.26) v1(96.16,53.67) v1(97.03,53.64) v1(97.08,55.52) v1(98.22,55.5) v1(101.47,57.94) v1(101.98,54.86) v1(102.21,52.32) v1(104.8,57.48) v1(104.8,55.07) v1(104.75,52.32) v6(94.18,55.68)
+V1P0A_VCCAMPHYPLL: length 0.7
  TOP w0.203: PCH1.C44 71.41,64.03 PCH1.B43
+V1P0A_VCCAPLL: length 32.9
  TOP w0.152: v3(59.34,48.95) PCH1.AN19
  TOP w0.254: v3(53.04,49.06) 53.15,48.95 53.15,48.45 53.49,48.11 53.82,48.11 54.08,47.85 54.08,46.63 v3(54.43,46.27)
  TOP w0.508: R556.1 35.33,44.26 35.33,44.58 C552.2 C553.2 40.44,45.44 41.58,46.58 44.42,46.58 v1(45.11,47.27)
  BOTTOM w0.102: v1(45.11,47.27) 44.48,47.27 v2(44.15,47.6)
  BOTTOM w0.254: v3(54.43,46.27) 54.71,46.56 55.09,46.56 56.44,47.91 56.75,47.91 57.63,48.79 57.63,49.1 57.98,49.45 58.84,49.45 v3(59.34,48.95)
  BOTTOM w0.508: v3(53.04,49.06) 47.41,49.06 46.35,48.01 45.75,48.01 45.11,47.37 v1(45.11,47.27)
+V1P0A_VCCF24_1P0: length 26.3
  TOP w0.152: PCH1.K3 51.51,60.06 51.42,60.15 PCH1.K2 50.93,59.94 50.54,59.94
  TOP w0.254: v1(47.22,70.31) 48.06,70.31 R409.1
  TOP w0.305: 50.54,59.94 47.42,59.94 46.79,60.58
  TOP w0.508: 46.79,60.58 44.37,62.99 C491.2 ; C491.2 45.21,64.16 45.21,65.81 44.12,66.9 v1(44.12,71.35) ; C491.2 C490.2 41.74,62.73 R446.1
  BOTTOM w0.254: v1(47.22,70.31) 45.21,70.31 v2(45.08,70.43) 44.17,71.35 v1(44.12,71.35)
+V1P0A_VCCST: length 733.6
  TOP w0.203: v1(128.17,18.95) 128.17,16.23 128.98,15.42 128.98,14.12 128.09,13.23 122.71,13.23 v1(120.78,15.16) ; R159.2 178.46,208.5 178.46,207.39 180.47,205.38 184.25,205.38 v1(184.73,204.9) ; v1(28.3,44.8) 28.65,44.44 28.65,35.26 27.48,34.09 25.32,34.09 v1(25.22,33.99) ; v1(39.01,19.49) 39.01,19.86 39.57,20.42 39.57,22.2 v1(39.37,22.4)
  TOP w0.254: R265.1 R268.1 70.33,176.63 v1(70.33,170.36) ; v1(147.57,180.31) 148.77,180.31 v1(148.82,180.37) v1(149.96,180.37) 150.55,179.78 151.66,179.78 v1(152.25,180.37) ; v1(72.31,170.46) 72.85,169.93 R276.1 73.03,161.4 66.34,154.71 v3(66.34,150.16) 66.34,146.56 63.27,143.48 63.27,141.58 60.1,138.4 55.55,138.4 54.91,137.77 49.48,137.77 40.11,128.4 35.69,128.4 v1(35.59,128.3) ; v1(28.3,44.8) 28.3,49.3 32.54,53.54 32.54,54.18 32.99,54.64 35.69,54.64 R487.1
  TOP w0.381: CPU1.V6 108.84,150.5 108.28,150.5 CPU1.V5 107.92,150.5 107.36,150.5 CPU1.V4
  TOP w0.508: R159.2 177.54,209.73 176.71,210.57 v1(176.38,210.57) R155.2 ; C305.1 73.85,148.02 73.85,144.59 73.56,144.3 v1(73.33,144.3) ; R155.2 R142.2 ; R155.2 R158.2 ; CPU1.V4 v5(106.73,149.86)
  BOTTOM w0.203: v1(120.78,15.16) 113.66,15.16 109.73,19.1 104.19,19.1 103.15,18.06 103.15,11.46 98.76,7.06 83.21,7.06 81.79,8.48 75.23,8.48 74.47,9.25 71.73,9.25 70.99,8.51 57.25,8.51 55.37,10.39 54.56,10.39 51.77,13.18 49.81,13.18 44.98,18.01 42.29,18.01 41.83,18.47 41.02,18.47 39.78,19.71 39.23,19.71 v1(39.01,19.49) ; v1(184.73,204.9) 185.06,204.57 188.14,204.57 189.31,203.4 196.34,203.4 197.71,202.03 197.71,123.98 196.62,122.89 196.62,117.98 195,116.36 195,113.26 195.94,112.32 v2(195.94,104.42) 195.94,92.2 185.42,81.69 185.42,75.39 187.3,73.51 187.3,47.12 184.84,44.65 184.84,23.6 171.55,10.31 155.14,10.31 153.75,11.71 151.71,11.71 149.78,9.78 142.29,9.78 133.12,18.95 v1(128.17,18.95) ; v1(39.37,22.4) 38.13,23.65 32.64,23.65 32.11,23.11 31.45,23.11 30.63,22.3 29.49,22.3 29.36,22.43 26.77,22.43 25.2,24 25.2,28.91 25.48,29.18 25.48,33.73 v1(25.22,33.99)
  BOTTOM w0.254: SC54.1 25.27,43.76 24.51,44.53 24.51,47.77 19.86,52.41 19.86,68.86 18.95,69.77 18.95,83.34 25.76,90.14 25.76,96.01 22.86,98.91 22.86,103.86 24.05,105.05 24.05,106.6 36.09,118.64 36.09,127.79 v1(35.59,128.3) ; v1(152.25,180.37) 152.81,180.92 152.81,183.95 162.41,193.55 162.41,199.14 165.58,202.31 165.96,202.31 166.47,202.82 166.47,203.43 167.77,204.72 169.11,204.72 170.79,206.4 171.63,206.4 173,207.77 173.89,207.77 176.38,210.26 v1(176.38,210.57) ; v1(72.31,170.46) 70.43,170.46 v1(70.33,170.36) ; v3(74.24,150.01) 73.86,150.39 66.57,150.39 v3(66.34,150.16) ; SR6.1 147.68,180.21 v1(147.57,180.31)
  BOTTOM w0.305: SR9.1 v1(152.25,180.37) ; SR7.1 v1(148.82,180.37) ; SR8.1 v1(149.96,180.37)
  BOTTOM w0.508: SC54.1 26.49,43.94 SC53.1 28.3,44.37 v1(28.3,44.8) ; v1(73.33,144.3) 78.31,144.3 86.26,152.25 90.37,152.25 92.13,150.5 106.09,150.5 v5(106.73,149.86)
+V3P3_WLAN: length 1.1
  BOTTOM w0.508: SC40.1 45.59,121.98 v1(45.92,122.31)
  vias: v1(28.4,122.02)
+VBAT: length 406.4
  TOP w0.254: v1(38.23,102.34) 37.92,102.03 26.06,102.03 24.43,100.41 22.35,100.41 21.64,99.69 21.64,90.09 28.17,83.57 28.17,73.81 19.81,65.46 19.81,49.2 14.35,43.74 v1(14.12,43.74) ; v1(121.39,9.04) 121.67,9.04 124.97,5.74 126.87,5.74 127.53,6.4 129.51,6.4 130.66,5.26 179.6,5.26 197.21,22.86 197.21,54.48 195.68,56.01 195.68,62.13 R434.2 ; v1(51.49,131.75) 49.73,131.75 46.02,128.04 46.02,126.06 v1(45.44,125.48)
  BOTTOM w0.254: v1(45.44,125.48) 45.44,125.27 44.27,124.1 44.27,115.01 38.38,109.12 38.38,102.49 v1(38.23,102.34) ; v1(121.39,9.04) 120.9,9.53 114.45,9.53 113.33,10.64 106.55,10.64 104.44,8.53 102.41,8.53 99.49,5.61 82.32,5.61 80.9,7.04 74.55,7.04 73.96,7.62 73.48,7.62 72.77,6.91 56.77,6.91 55.91,7.77 52.76,7.77 44.27,16.26 40.82,16.26 39.57,17.5 38.84,17.5 37.26,19.08 33.91,19.08 33.2,18.36 33.2,17.75 30.05,14.6 27.38,14.6 26.59,15.39 24.87,15.39 24.21,16.05 19.81,16.05 17.07,18.8 17.07,21.72 15.8,22.99 14.48,22.99 13.54,23.93 13.54,29.06 14.3,29.82 14.3,43.71 v1(14.12,43.74) ; BAT1.P 59.52,142.65 53.92,137.06 53.92,133.99 51.69,131.75 v1(51.49,131.75)
+VBAT_IO: length 178.7
  TOP w0.178: U38.29 113.79,28.73
  TOP w0.203: 113.79,28.73 113.89,28.63
  TOP w0.254: R416.1 187.71,69.56 C467.1 ; 113.89,28.63 114.22,28.3 115.19,28.3 115.57,27.91 C610.1 116.26,26.66 116.26,24.51 118.54,22.22 118.54,3.63 v1(117.47,2.57) ; CLR_CMOS.2 185.65,69.72 C467.1 ; C467.1 188.51,69.09 189.28,69.09 190.3,68.07 193.95,68.07 196.12,65.9 196.12,56.42 197.66,54.88 197.66,22.44 179.9,4.67 130.25,4.67 129.46,5.46 v1(127.76,5.46)
  BOTTOM w0.254: v1(127.76,5.46) 127.76,4.93 123.95,1.12 120.6,1.12 119.02,2.69 117.6,2.69 v1(117.47,2.57)
+VCC: length 225.1
  TOP w0.254: R764.1 9.28,2.46 16.46,2.46 17.25,3.25 18.62,3.25 19.41,4.04 19.41,6.05 21.87,8.51 21.87,9.74 R755.1 23.52,11.39 v1(23.52,12.12) ; v1(122.89,43.79) 121.38,43.79 R564.1 ; C617.2 85.03,26.38 84.81,26.16 84.81,24.89 85.65,24.05 86.41,24.05 87.13,23.33 87.13,21.81 87.5,21.44 87.5,19.63 v1(88.26,18.87)
  TOP w0.305: v1(33.05,23.09) 32.84,23.09 32.16,22.4 R730.2 ; C621.1 34.8,22.83 v1(35.34,22.83)
  TOP w0.381: v1(160.13,71.78) 160.13,72.46 QN20.4 ; C628.1 83.32,15.24 v1(84,15.24) ; v1(87.53,15.44) 87.71,15.63 C626.1 ; C634.1 53.35,12.95 v3(53.77,12.95) ; C625.1 v1(85.6,15.32) ; v1(35.34,22.83) 35.34,22.69 34.82,22.17 R731.2
  TOP w0.508: v1(189.46,23.52) 188.95,24.03 D21.N 188.05,25.04 180.39,32.69 v1(180.39,36.98) ; R120.1 125.83,214.25 125.45,213.87 QN10.S 123.67,213.72 v1(122.14,212.18) ; R720.1 v1(192.56,25.02) ; U30.1 14.87,74.01 14.55,73.69 v1(13.36,73.69) ; v1(195.71,122.86) R391.2 ; v1(145.64,38.99) 145.46,39.17 145.46,41.03 141.88,44.6 141.88,48.18 143.48,49.78 144.37,49.78 145.39,50.8 145.39,52.01 144.81,52.6 R505.1 ; v1(172.44,73.46) 184.43,73.46 186.03,75.06 186.03,82.3 194.34,90.6 v1(194.34,91.59) ; v1(14.33,66.22) v1(14.33,65.13) 13.72,64.52 U33.3 ; v1(33.88,34.42) 33.88,29.84 v1(34.52,29.21) ; C617.2 R706.1 ; v1(95.73,9.96) C636.1
  BOTTOM w0.254: v1(128.19,45.1) 125.21,45.1 123.9,43.79 v1(122.89,43.79)
  BOTTOM w0.305: v1(33.05,23.09) 35.08,23.09 v1(35.34,22.83)
  BOTTOM w0.508: BZ.P 193.73,26.19 v1(192.56,25.02) 191.06,23.52 v1(189.46,23.52) ; 163.17,73.46 v1(172.44,73.46) ; v1(14.33,65.13) v1(14.33,66.22) 14.33,66.77 13.74,67.36 13.74,73.3 v1(13.36,73.69) ; v1(194.34,91.59) 194.34,121.49 v1(195.71,122.86) ; v1(180.39,36.98) 165.65,36.98 ATX_POWER.4
  vias: v1(14.33,64.13) v1(14.33,63.37) v1(18.62,24.54) v1(18.62,23.72) v1(31.62,61.44) v1(31.85,57.05) v1(32.36,61.47) v1(32.61,57.05) v1(33.22,61.21) v1(33.5,57.05) v1(34.04,61.21) v1(34.39,57.1) v1(34.85,61.21) v1(35.28,57.1) v1(71.6,203.33) v1(72.36,203.33) v1(73.25,203.96) v1(74.02,203.96) v1(100.53,216.13) v1(100.51,210.49) v1(101.04,216.66) v1(128.19,49.81) v1(128.52,50.5) v1(129.16,49.83) v1(129.59,50.55) v1(130.07,49.81) v1(134.98,58.85) v1(135.79,60.38) v1(135.81,59.61) v1(135.79,58.85) v1(160.15,70.97) v1(160.68,38.48) v1(161.98,34.59) v1(162.08,38.48) v1(162.41,221.89) v1(163.17,221.89) v1(163.58,37.59)
+VCC3: length 904.9
  TOP w0.127: R324.2 67.87,120.32 60.78,113.23 57.91,113.23 55.37,115.77 55.37,116.69 54.2,117.86 QSW2.1 ; v3(55.65,52.53) 55.92,52.53 PCH1.AD13
  TOP w0.178: U7.14 v1(187.64,224.61)
  TOP w0.254: v1(32.23,38.28) 32.05,38.46 32.05,43.54 32.97,44.45 32.97,47.37 v1(33.73,48.13) ; R600.2 36.28,37.36 34.92,37.36 ; v1(183.31,120.65) 182.62,120.65 C363.2 182.67,120.46 182.67,118.3 U29.5 ; 84.76,71.09 85.41,70.44 R406.2 ; 84.76,71.09 87.52,71.09 R407.2 R413.2 R418.2 ; 84.76,71.09 v1(84.66,71.2) ; v1(34.14,39.65) 34.14,39.12 34.7,38.56 34.7,37.59 34.92,37.36 ; v1(97.85,24.5) 97.85,23.89 95.87,21.9 R734.2 ; D24.2 19.21,11.59 R749.1 17.14,12.19 v1(17.14,11.38) ; v1(49.23,92.15) 49.23,91.81 C417.1 C418.1 51.87,91.16 55.07,91.16 R379.2 56.32,90.72 R378.1 ; v1(182.68,113.94) 182.68,113.95 R345.1 183.62,112.98 183.2,112.57 R349.1 ; v1(110.13,207.82) 110.03,207.72 103.33,207.72 101.47,205.87 101.47,203.78 100.84,203.15 98.38,203.15 R199.2 ; R683.2 52.69,28.54 v1(52.76,28.47) ; R357.1 31.8,107.6 28.85,104.65 25.7,104.65 v1(25.35,104.29) ; v1(187.66,219.48) 187.78,219.35 187.78,206.25 187.07,205.54 186.28,205.54 185.22,206.6 180.49,206.6 179.22,207.87 179.22,209.14 178.56,209.8 178.56,210.06 R156.2 178.06,211.65 R143.2 ; QN6.1 154.69,218.74 R103.1 154.39,217.63 151.62,217.63 QN8.1 150.06,217.73 148.09,217.73 QN7.1 147.36,218.2 146.74,217.58 146.15,217.58 ; v1(27.18,11.94) 27.18,12.17 25.37,13.97 25.37,14.96 26.03,15.62 26.03,17.37 26.82,18.16 27.41,18.16 28.5,17.07 30.2,17.07 30.71,17.58 30.71,18.44 31.32,19.05 33.02,19.05 34.19,20.22 34.19,22.68 33.83,23.04 33.83,24.74 35.23,26.14 35.76,26.14 36.02,25.88 36.02,25.65 36.27,25.4 37.26,25.4 37.74,25.88 v1(37.74,26.57) ; R366.2 27.68,99.26 26.59,99.26 26.16,98.83 24.38,98.83 v1(24.18,98.63) ; v1(40.67,26.57) 40.67,27.53 41.29,28.16 41.29,28.54 ; v1(61.21,23.85) 61.87,24.51 61.87,26.17 R695.2 61.51,26.27 61.06,26.72 v1(61.06,27.76) ; 41.29,28.54 41.73,28.98 45.44,28.98 46.66,30.2 49.2,30.2 49.96,29.44 50.72,29.44 51,29.72 51,30.61 51.33,30.94 52.13,30.94 R647.2 52.55,30.77 52.76,30.56 v1(52.76,28.47) ; 41.29,28.54 40.54,29.29 35.84,29.29 34.92,30.2 34.92,37.36 ; R546.1 179.14,45.47 ; v1(52.76,28.47) 53.28,28.47 R671.2
  TOP w0.381: R660.2 62.38,31.46 61.42,30.51 R659.2 61.32,30.43 62,29.74 v1(62.05,29.74) ; R658.2 60.17,30.15 v1(60.6,29.72) ; v1(195.78,232.11) 197.54,230.35 197.54,227.66 195.94,226.06 195.94,224.54 192.51,221.11 192.51,219.84 190.73,218.06 189.69,218.06 v1(189.61,218.14) 189.53,218.21 189.53,220.55 187.88,222.2 ; R632.1 v1(78.08,32.44) R656.1 ; R28.1 113.05,230.13 QN1.1 114.04,230.13 114.66,229.51 114.66,227.5 QN2.1 114.75,225.81 R35.1 ; R593.2 R600.2 ; R652.1 71.95,30.86 v1(73.38,30.86) 73.92,30.86 R653.1 ; v1(84.89,44.6) 85.29,45 R550.2 R545.2 ; R655.1 76.55,30.64 v1(76.23,30.96) ; R607.1 v1(61.44,35.1) ; 187.88,222.2 v1(187.88,222.76) ; 187.88,222.2 184.46,222.2 PFB6.1 ; R728.2 42.44,23.64 42.69,23.64 v1(42.7,23.65) 43.08,23.26 R727.2 ; v1(85.95,43.08) 85.72,42.84 R567.2 ; v1(118.14,28.58) 118.67,28.58 119.28,27.97 R684.2
  TOP w0.406: R677.1 R676.2 v1(70.87,27.84) R675.1 ; R543.2 88.82,46.69 88.9,46.61 v1(88.93,46.63) ; v1(88.98,64.72) 88.52,64.26 R436.2 ; v1(90.3,60.35) 90.72,59.93 90.72,58.51 89.08,56.87 v1(88.93,56.87) 88.23,56.87 R459.2 R455.2 ; U23.5 27.35,182.81 26.99,183.17 R253.2 25.93,183.17 25.5,183.59 25.5,184.56 v1(25.93,184.99) ; R451.2 v1(86.08,59.18) ; R480.2 88.95,55.35 v1(88.95,55.7) ; C157.1 14.96,210.28 C128.1 15.31,212.15 CODEC.1
  TOP w0.508: v1(195.78,232.11) 195.66,232.23 PFB2.1 ; v1(54.99,180.8) 61.73,180.8 70.84,189.9 70.84,192.35 73.3,194.82 77.6,194.82 88.54,205.77 98.76,205.77 102.54,209.55 108.89,209.55 109.83,210.49 110.57,210.49 111.4,211.33 v1(111.4,211.99) 111.4,213.97 111.68,214.24 C121.1 112.12,220.52 QN5.1 113.57,221.42 114.75,222.6 R35.1 ; v1(105.13,17.96) 104.72,18.36 104.72,21.59 105.81,22.67 ; 130.89,215.49 130.02,215.49 128.75,214.22 128.75,213.11 ; 130.89,215.49 131.78,214.6 142.57,214.6 QN9.1 144.75,216.79 145.36,216.79 146.15,217.58 146.15,217.7 144.93,218.92 144.93,219.89 143.61,221.21 v1(143.61,222.4) ; 130.89,215.49 130.89,219.4 R86.1 131.45,220.78 QN4.1 ; v1(83.89,25.43) C616.2 83.16,23.39 LPC_DEBUG.9 ; ATX_POWER.1 176.38,35.08 C599.1 ; v1(135.76,27.71) 136.14,27.34 R692.2 136.75,26.32 R704.2 ; R526.1 154.82,203.17 v1(154.15,203.84) ; R177.2 R176.2 v1(155.3,206.12) 152.63,206.12 147.04,211.71 130.15,211.71 128.75,213.11 ; v1(10.92,201.55) 11.53,200.94 11.53,199.97 10.54,198.98 10.54,193.42 6.07,188.95 6.07,187.2 ; R206.2 45.85,201.3 45.49,201.3 v1(44.2,202.59) ; 128.75,213.11 128.7,213.16 v1(126.36,213.16) ; R65.1 R64.1 148.82,223.04 v1(148.82,223.65) ; v1(21.08,207.04) 21.08,206.78 20.42,206.12 RJ1.3 ; R638.2 123.82,32.99 v1(124,33.17) ; v1(106.63,43.69) 105.26,42.32 R573.2 ; R497.2 v1(191.01,53.89) ; PFB10.2 111.16,43.01 v1(111.2,42.98) ; v1(12.42,11.4) 12.42,12.83 11.31,13.94 R745.2 R744.2 ; R225.2 47.98,195.36 47.98,194.16 48.69,193.45 v1(48.69,193.07) 49.1,192.65 R232.2 ; v1(16.1,207.06) 15.54,206.5 C157.1 14.96,206.25 13.54,204.83 v1(13.31,204.83) 12.79,205.35 D13.2 ; R629.1 v1(71.73,35.18) R612.1 ; R608.1 62.71,35.85 v1(62.71,35.18) 62.71,34.39 R627.1 ; 179.14,45.47 179.14,43.37 ATX_POWER.13 ; R144.2 42.28,210.98 43.41,209.85 v1(43.41,205.66) ; R454.2 R451.2 ; R613.2 v1(72.87,35.18) ; R362.1 v1(56.36,103)
  TOP w0.635: C361.1 53.95,121.39 54.2,121.13 QSW2.1
  TOP w0.762: C361.1 54.21,122.08 54.76,122.63 54.76,123.24 v1(55.12,123.6)
  BOTTOM w0.127: v3(55.65,52.53) 55.65,52.63 55,53.28 54.08,53.28 53.47,53.9 49.37,53.9 49.33,53.94
  BOTTOM w0.178: v1(187.88,222.76) 187.64,223 v1(187.64,224.61)
  BOTTOM w0.254: v1(61.21,23.85) 61.04,23.67 56.72,23.67 55.42,24.97 55.42,27.61 54.79,28.24 52.98,28.24 v1(52.76,28.47) ; v1(25.35,104.29) 25.15,104.5 24.21,104.5 23.27,103.56 23.27,99.54 v1(24.18,98.63) ; v1(86.08,59.18) 86.77,59.18 88.93,57.02 v1(88.93,56.87) 88.93,55.73 v1(88.95,55.7) 88.01,54.76 88.01,47.55 v1(88.93,46.63) ; v1(110.13,207.82) 111.4,209.09 v1(111.4,211.99) ; v1(12.42,11.4) 12.7,11.13 16.89,11.13 v1(17.14,11.38) 20.83,11.38 21.69,12.24 22.38,12.24 23.24,11.38 26.62,11.38 v1(27.18,11.94) ; v1(73.38,30.86) 73.05,31.19 69.62,31.19 69.29,31.52 69.29,32.29 69.7,32.69 70.33,32.69 71.73,34.09 v1(71.73,35.18) ; v1(189.61,218.14) 188.29,219.46 187.68,219.46 v1(187.66,219.48) ; v1(42.7,23.65) 41.1,23.65 38.18,26.57 v1(37.74,26.57) 37.74,26.82 38.35,27.43 39.04,27.43 39.47,27 40.23,27 v1(40.67,26.57) ; v1(33.73,48.13) 33.88,48.29 35.97,48.29 36.7,47.55 37.62,47.55 41.76,51.69 44.12,51.69 45.97,53.54 48.46,53.54 48.86,53.94 49.33,53.94 SC48.1 ; v1(80.8,29.13) 80.7,29.24 80.7,33.63 81.76,34.7 81.76,37.82 79.93,39.65 79.93,41.78 80.72,42.57 81.79,42.57 82.98,43.76 82.98,44.75 82.73,45.01 82.73,45.95 83.06,46.28 83.72,46.28 84.23,45.77 84.23,45.26 v1(84.89,44.6) ; v1(183.31,120.65) 182.67,120 182.67,113.98 182.68,113.97 v1(182.68,113.94) 181.79,113.06 181.79,103.12 183.31,101.6 183.31,79.58 172.19,68.45 172.19,44.77 ATX_POWER.13 ; v1(34.14,39.65) 33.6,39.65 v1(32.23,38.28)
  BOTTOM w0.381: v1(78.08,32.44) 78.08,32.39 76.65,30.96 v1(76.23,30.96) 76.12,30.86 v1(73.38,30.86)
  BOTTOM w0.508: v1(90.3,60.35) 88.24,62.41 88.24,63.98 v1(88.98,64.72) 88.26,64.72 87.48,65.51 87.48,66.7 85.41,68.76 85.41,68.79 84.66,69.55 v1(84.66,71.2) ; v1(43.41,205.66) 43.41,203.38 v1(44.2,202.59) 44.81,201.98 48.31,201.98 49.33,200.96 49.33,196.8 48.01,195.48 48.01,193.75 v1(48.69,193.07) 48.69,192.47 54.99,186.18 v1(54.99,180.8) ; v1(10.92,201.55) 13.31,203.94 v1(13.31,204.83) ; v1(21.08,207.04) 21.06,207.06 v1(16.1,207.06) ; v1(126.36,213.16) 126.01,213.51 121.39,213.51 119.86,211.99 v1(111.4,211.99) ; v1(85.95,43.08) 84.89,44.15 v1(84.89,44.6) ; v1(72.87,35.18) v1(71.73,35.18) ; v1(106.63,43.69) 106.88,43.94 110.24,43.94 v1(111.2,42.98) ; v1(61.06,27.76) 62.05,28.75 v1(62.05,29.74) 62.05,33.32 61.44,33.93 v1(61.44,35.1) ; v1(195.78,232.11) 195.78,233.51 192.95,236.35 174.98,236.35 174.27,235.64 167.97,235.64 157.33,224.99 154.25,224.99 151.64,222.38 149.45,222.38 148.82,223.01 ; 148.82,223.01 148.21,222.4 v1(143.61,222.4) ; 148.82,223.01 v1(148.82,223.65) ; EC11.1 26.55,185.6 v1(25.93,184.99) ; v1(154.15,203.84) 154.15,204.98 v1(155.3,206.12) ; SR34.1 v1(105.13,17.96)
  vias: v1(15.54,91.01) v1(15.57,94.74) v1(15.57,93.85) v1(15.57,92.86) v1(15.57,91.95) v1(15.57,90.04) v1(15.57,89.18) v1(15.57,88.32) v1(22.68,94.13) v1(22.68,92.76) v1(22.68,91.26) v1(22.96,94.95) v1(23.62,94.16) v1(23.62,93.27) v1(23.65,92.38) v1(23.62,91.54) v1(23.62,90.65) v1(47.52,88.57) v1(47.55,87.76) v1(47.57,86.92) v1(48.77,83.36) v1(66.52,77.93) v1(67.34,77.93) v1(68.12,77.93) v1(72.87,77.9) v1(72.9,77.06) v1(72.9,76.28) v1(73.76,77.9) v1(73.79,77.06) v1(73.79,76.28) v1(88.93,76.58) v1(88.93,75.64) v1(88.93,74.75) v1(89.81,76.58) v1(89.81,75.64) v1(89.81,74.75) v1(95.76,76.58) v1(95.76,75.64) v1(95.76,74.75) v1(96.65,76.58) v1(96.65,75.64) v1(96.65,74.75) v1(105.56,76.5) v1(105.56,75.56) v1(105.56,74.68) v1(106.45,76.5) v1(106.45,75.56) v1(106.45,74.68) v1(107.92,8.89) v1(108.38,23.57) v1(108.43,22.81) v1(108.58,7.14) v1(108.58,6.32) v1(108.66,9.09) v1(111.94,75.11) v1(111.94,74.37) v1(111.94,73.61) v1(112.8,75.11) v1(112.83,74.37) v1(112.83,73.61) v1(113,22.73) v1(113.89,22.73)
+VCCGT: length 62.4
  TOP w0.203: SP9.1 177.01,133.79 L18.2 ; L17.2 177.01,151.19 SP7.1
  TOP w0.254: R214.2 161.04,199.56 162.74,197.87 167.89,197.87 v1(168.2,198.17)
  BOTTOM w0.203: v1(168.2,198.17) 168.2,197.61 167.16,196.56 167.16,191.58 167.18,191.56 167.18,182.21 155.83,170.85 155.83,166.09 156.57,165.35 165.71,165.35 166,165.07 EC19.1
  vias: v1(133.32,152.91) v1(133.32,152.02) v1(133.32,150.88) v1(133.32,149.99) v1(133.32,148.97) v1(133.32,148.08) v1(133.32,146.94) v1(133.32,146.05) v1(133.32,145.16) v1(133.32,144.27) v1(133.32,143.26) v1(133.32,142.37) v1(133.45,141.27) v1(133.45,140.39) v1(134.57,143.48) v1(160.76,161.04) v1(163.3,157.99) v1(163.3,152.78) v1(163.3,151.13) v1(163.3,147.57) v1(164.13,161.09) v1(164.31,156.34) v1(164.31,149.23) v1(164.77,163.5) v1(164.82,143.38) v1(165.58,157.61) v1(165.58,155.07) v1(165.58,150.5) v1(165.58,147.95) v1(165.91,162.23) v1(166.47,140.97) v1(166.73,145.8) v1(166.85,159.51) v1(166.85,156.34) v1(166.85,149.23) v1(166.85,142.88) v1(167.21,163.42) v1(173.08,153.42) v1(173.81,150.29) v1(174.04,152.53) v1(174.35,135.76) v1(175.26,153.03) v1(175.62,135.76) v1(175.62,131.95) v1(176.48,153.03) v1(176.5,132.33) v3(137.26,155.35) v3(138.2,155.35) v3(138.18,152.63) v3(138.18,150.83) v3(138.18,149) v3(139.06,159) v3(139.09,157.15) v3(139.06,155.32) v3(140,159.03) v3(140.03,157.12) v3(140.03,155.3) v3(140,152.6) v3(140,150.83) v3(140.03,149) v3(140.94,159.03) v3(140.92,155.32) v3(141.83,157.15) v3(141.81,155.35) v3(141.83,152.63) v3(141.83,150.77) v3(141.86,159) v3(143.23,149.61) v3(144.12,160.66) v3(144.63,157.73) v3(144.63,154.05) v3(144.75,149.99) v3(145.77,161.93) v3(146.28,157.73) v3(146.28,154.05) v3(146.41,149.99) v3(147.93,157.73) v3(147.93,154.05) v3(148.06,149.99) v3(148.31,161.93) v3(149.71,157.73) v3(149.71,154.05) v3(149.83,149.99) v3(150.72,161.93) v3(151.49,157.73) v3(151.49,154.05) v3(151.61,149.99) v3(152.12,163.32) v3(153.39,157.73) v3(153.39,154.05) v3(153.52,149.99) v3(153.9,164.34) v3(155.04,157.73) v3(155.04,154.05) v3(155.17,149.99) v3(155.93,164.34) v3(156.82,157.73) v3(156.82,154.05) v3(156.95,149.99) v3(158.22,164.34) v3(158.34,148.72)
+VCCIO: length 104.5
  TOP w0.254: C340.2 v1(65.63,135.25) ; v1(51.92,141.61) 53.09,141.61 53.54,142.06 55.75,142.06 62.76,149.07 62.76,157.61 67.87,162.71 67.87,167.77 66.78,168.86 66.78,170.41 64.74,172.44 64.74,178.36 70.03,183.64 R255.2 ; v1(52.88,133.76) 53.06,133.93 57.86,133.93 58.42,134.49 65.4,134.49 ; v1(56.85,123.67) 56.27,123.09 R327.1
  TOP w0.356: CPU1.AK11 v5(115.33,138.89) ; CPU1.AK14 v5(118.07,138.89) ; v5(126.66,140) CPU1.AJ23
  TOP w0.381: CPU1.AK24 127.64,138.43 v5(127.2,138.87) ; CPU1.P8 111.02,153.8 111.99,153.8 ; 112.93,149.4 CPU1.W8 ; 111.61,154.43 111.61,155.04 CPU1.M8 ; CPU1.U8 111.66,151.23 ; CPU1.T8 111.66,152.15
  BOTTOM w0.254: v1(52.88,133.76) 52.88,134.34 51.92,135.31 v1(51.92,141.61) ; v1(56.85,123.67) 57.25,124.08 57.25,127.61 60.17,130.53 60.17,132.79 61.65,134.26 64.64,134.26 v1(65.63,135.25)
  BOTTOM w0.381: 118.07,139.66 v5(118.07,138.89)
  vias: v1(65.79,132.79) v1(65.76,131.01) v1(67.28,133.86) v1(69.55,135.03) v1(69.88,133.07) v1(69.85,131.85) v1(70.87,132.97) v1(71.27,134.16) v1(71.91,134.98) v1(113.16,144.04) v1(113.51,145.67) v1(113.51,144.78) v1(113.97,144.04) v2(66.7,136.58)
+VCCPGPPA: length 23
  TOP w0.254: PCH1.BA31 65.53,44.89 v3(65.15,45.26)
  TOP w0.508: v1(69.88,31.8) 68.82,31.8 R651.2
  BOTTOM w0.356: 65.79,43.69 65.54,43.94 65.54,44.87 v3(65.15,45.26)
  BOTTOM w0.508: v1(69.88,31.8) 70.21,31.8 72.21,33.81 73.58,33.81 v2(73.61,33.83) 74.6,34.82 74.6,35.86 74.12,36.35 72.42,36.35 71.65,37.11 71.65,37.49 67.01,42.14 67.01,42.48 65.79,43.69
+VCCPLL_OC_R: length 4
  TOP w0.356: CPU1.AJ9 111.76,140.76 R299.1
+VCCPRIM_1P0: length 2.8
  TOP w0.152: PCH1.AL22 60.8,50.01 v3(60.35,50.01)
  BOTTOM w0.305: v3(60.35,50.01) 60.55,50.01 61.06,49.5 61.06,49.24 SR19.2
+VDD_CLK: length 37.2
  TOP w0.254: 94.92,44.17 94.97,44.12 94.97,43.84 95.14,43.67 U37.2 ; 98.09,45.19 97.88,44.97 U37.16 ; U37.9 97.88,40.02 97.64,39.78 C576.2 ; C556.2 99.61,44.01 99.27,43.67 U37.15 ; C570.2 94.72,40.67 95.22,41.17 U37.7
  TOP w0.508: R594.2 99.48,38.93 C579.2 99.16,39.24 97.67,39.24 C576.2 97.35,39.21 96.4,38.26 R592.1 ; C556.2 100.03,45.75 v1(99.76,46.01) C549.2 98.78,45.87 98.09,45.19 ; v1(97.05,45.39) 96.49,45.95 96.25,45.95 C548.2 96.19,45.92 94.92,44.65 94.92,44.17 ; R592.1 94.99,38.26 94.23,39.02 C570.2 ; R592.1 96.29,38.18 96.29,37.62 v1(96.62,37.29)
  BOTTOM w0.508: v1(96.62,37.29) 96.62,37.97 99.09,40.44 v2(99.09,44.35) 99.76,45.03 v1(99.76,46.01) 97.67,46.01 v1(97.05,45.39)
+VIN_95V:
  vias: v1(113.13,62.1) v1(113.13,60.33) v1(113.51,65.15) v1(119.23,60.33) v1(119.23,58.55) v1(119.61,65.15) v1(121.01,65.13) v1(122.66,60.71)
+VIN_CPU: length 86.8
  TOP w0.508: v1(193.4,112.4) 195.81,109.98 195.81,91 186.92,82.11 186.92,74.68 v1(186.03,73.79) ; v1(152.91,205.33) 153.26,204.98 153.9,204.98 ; R414.2 188.86,56.61 v1(186.66,58.8)
  BOTTOM w0.508: v1(189.05,122.33) 192.13,119.25 192.13,113.66 v1(193.4,112.4) ; v1(152.91,205.33) 151.36,203.78 151.36,201.8 150.34,200.79 v1(147.29,200.79) ; v1(186.66,58.8) 186.66,73.15 v1(186.03,73.79)
  vias: v1(122.91,207.39) v1(123.67,206.76) v1(127.63,203.17) v1(127.61,202.06) v1(131.29,201.04) v1(132.56,201.8) v1(132.82,203.07) v1(136.5,202.44) v1(137.36,203.25) v1(137.39,201.68) v1(143.74,201.78) v1(143.76,200.94) v1(143.76,200.1) v1(146.02,200.79) v1(146.02,192.41) v1(147.04,193.8) v1(148.06,202.31) v1(188.32,160.4) v1(188.57,156.21) v1(188.75,167.77) v1(188.75,166.88) v1(189.61,167.74) v1(189.59,159.77) v1(189.76,132.28) v1(190.47,156.97) v1(190.68,132.26) v1(191.11,161.42) v1(191.11,160.27) v1(191.8,132.69) v1(192.38,156.21) v1(192.63,132.66) v1(192.71,138.4) v1(193.09,189.23) v1(193.7,171.55) v1(193.73,169.65) v1(193.65,168.02) v1(193.67,138.23) v1(193.7,136.93) v1(193.75,153.11) v1(193.78,152.02) v1(193.78,150.88) v1(194.67,189.23) v6(179.17,191.13) v6(182.85,189.74) v6(183.87,191.13) v6(185.52,192.66)
+VIN_SA:
  vias: v1(104.93,204.11) v1(104.95,205) v1(110.85,205.49) v1(110.85,203.96) v1(111.02,201.6) v1(112.12,202.31) v1(113.51,203.96) v1(113.64,201.04) v1(115.04,202.44) v1(119.23,207.39) v1(121.01,204.55)
AV1N: length 94.7
  TOP w0.203: R71.2 v1(173.2,222.76) 173.2,223.53 R47.1 R48.1 ; v1(129.32,189.17) 128.9,189.59 126.25,189.59 SP3.2
  BOTTOM w0.203: v1(173.2,222.76) 173.44,222.52 173.44,222.33 173.26,222.15 171.27,222.15 170.31,221.18 170.31,218.8 171.43,217.68 174.86,217.68 175.87,216.67 175.87,214.58 175.03,213.74 173.23,213.74 171.3,211.81 170.08,210.59 169.34,210.59 167.39,208.64 165.98,208.64 160.76,203.41 160.76,202.99 158.32,200.55 158.32,195.49 152.84,190.02 145.6,190.02 144.59,189 142.77,189 140.31,186.54 140.31,183.07 139.63,182.4 130.57,182.4 129.39,183.58 129.39,187.52 128.52,188.38 128.52,189.32 128.79,189.59 129.1,189.59 129.32,189.36 v1(129.32,189.17)
AV2N: length 60
  TOP w0.203: v1(145.67,188.21) 145.92,188.47 145.92,188.7 145.03,189.59 143.78,189.59 SP4.2 ; v1(182.47,210.06) R147.2 R146.1 R162.1
  BOTTOM w0.203: v1(145.67,188.21) 145.92,187.96 145.92,187.46 146.34,187.05 148.64,187.05 v2(148.92,186.77) 149.2,187.05 152.1,187.05 159.89,194.84 159.89,199.97 162.28,202.36 162.28,202.78 166.61,207.11 168.04,207.11 169.99,209.07 170.75,209.07 173.52,211.84 175.87,211.84 176.02,211.68 178.56,211.68 179.1,211.15 179.45,210.79 182.56,210.79 182.75,210.6 182.75,210.26 182.55,210.06 v1(182.47,210.06)
AV3N: length 73.2
  TOP w0.203: v1(183.72,219.1) 183.21,219.1 182.58,218.47 R98.1 R97.2 181.33,217.96 181.48,217.81 181.48,217.04 R113.1 ; SP5.2 178.62,170.2 178.62,170.76 176.56,172.82 172.04,172.82 171.02,173.84 171.02,179.41 170.18,180.25 170.18,181.89 170.59,182.3 171.25,182.3 v1(171.5,182.55)
  BOTTOM w0.203: v1(171.5,182.55) 171.5,182.47 171.31,182.27 171.03,182.27 170.92,182.38 170.92,194.59 177.18,200.85 177.18,203.35 179.65,205.82 184.38,205.82 186.82,208.25 186.82,217.14 185.1,218.86 183.96,218.86 v1(183.72,219.1)
DGND: length 7.7
  TOP w0.508: USB2_LAN.P10 82.65,221.66 82.65,217.65 81.23,216.23 R124.1
GND: length 1222
  TOP w0.102: v3(48.64,62.89) 48.64,62.99 48.11,63.53 48.11,68.48 v3(46.91,69.67) ; v3(54.38,52.53) 54.16,52.87 PCH1.AD8 ; v3(49.48,63.42) 49.25,63.42 48.62,64.06 48.62,68.48 49.66,69.52 49.66,71.55 v3(49.61,71.6) ; CPU1.D4 107.17,163.12
  TOP w0.114: 107.64,166.32 v5(107.64,166.34)
  TOP w0.127: PCH1.B6 53.41,64.31 53.41,64.67 53.41,64.67 52.91,65.18 52.83,65.18 ; v3(50.32,56.74) 50.76,57.18 PCH1.T1 PCH1.T2
  TOP w0.152: PCH1.AC1 50.51,53.71 v1(50.14,53.34) ; PCH1.P45 73,58.27 74.29,59.56 v3(74.57,59.56) ; PCH1.BE9 54.73,42.26 54.53,42.06 ; PCH1.BE28 63.73,42.78 63.73,42.22 v3(63.75,42.19) ; PCH1.BE14 57.03,42.01 v3(57.18,41.86) ; PCH1.A32 66.11,65.09 v3(66.19,65.18) ; v3(59.79,41.97) 59.79,42.24 59.3,42.73 PCH1.BE18 ; PCH1.AH45 72.38,51.42 73.28,50.52 v3(73.28,50.29) ; PCH1.AC45 74.81,53.73 75.21,54.13 v3(75.46,54.13) ; PCH1.BE23 61.58,42.36 v3(61.38,42.16) ; v3(74.83,56.67) 74.57,56.67 73.91,56 PCH1.V45 ; PCH1.C37 PCH1.B37 68.49,64.46 PCH1.A37 68.41,64.67 68.66,64.92 v3(69.06,64.92) ; PCH1.AH1 48.28,51.44 v3(48.21,51.51) ; U43.3 78.24,15.02 ; v4(66.17,42.27) 66.12,42.32 PCH1.BE32
  TOP w0.178: PCH1.BB16 58.07,44.07 v4(58.2,43.88) ; v4(65.01,43.88) 64.89,44.02 PCH1.BB30 ; PCH1.BB21 60.34,44.02 v4(60.47,43.87) ; PCH1.BB25 62.62,44.04 v4(62.72,43.88) ; PCH1.AM45 72.38,48.93 72.57,48.74 ; PCH1.AU45 72.43,46.88 v3(72.95,47.4) ; U38.54 v1(112.99,36.86) ; 78.24,15.02 v1(78.16,14.94) ; v3(62.92,65.05) 62.79,64.93 PCH1.A25 PCH1.B25 ; PCH1.AW13 56.34,45.73 v3(56.03,45.42)
  TOP w0.203: PCH1.AU1 50.2,46.87 v3(49.63,46.3) ; PCH1.BE37 68.42,42.74 v4(68.68,42.48) ; PCH1.BE40 70.03,42.57 v3(70.34,42.26) ; CPU1.AW3 106.27,131.4 106.73,131.86 v5(106.73,132.49) 106.08,132.49 105.63,132.03 CPU1.AV2 ; U31.4 147.6,73.08 v1(147.88,72.8) ; v1(145.29,69.7) 144.97,70.01 U31.19 144.97,72.1 U31.22 145.77,71.86 U31.21 145.77,70.63 146.41,70 v1(146.41,69.85) ; CPU1.V1 104.42,150.34 103.33,150.34 v5(102.84,149.86) ; PCH1.B6 53.12,64.02 52.86,63.75 ; v3(188.24,226.39) 188.04,226.19 U7.15 ; CPU1.AV38 140.48,131.39 140.02,131.85 v5(140.02,132.46)
  TOP w0.254: v1(157.4,199.49) 157.31,199.4 Q11.1 ; v1(98.2,11.25) 98.37,11.42 M2_2.27 ; M2_1.51 33.94,114.23 34.3,114.58 35.01,114.58 35.44,114.16 M2_1.45 35.44,108.94 36.73,107.65 v1(37.57,107.65) ; C7.2 v1(173.69,230.36) 173.86,230.19 U6.3 ; Q11.4 154.4,200.4 154.03,200.03 154.03,199.14 154.53,198.63 v1(155.3,198.63) ; CPU1.T1 104.61,152.15 105.03,151.73 105.78,151.73 CPU1.U3 ; C577.2 104.25,38.76 102.95,38.76 v1(102.26,38.07) ; v1(101.02,21.84) 100.94,21.84 100.36,22.42 M2_2.71 ; PCH1.D45 73.95,63.18 v3(74.29,63.53) ; 70.66,64.08 71.03,64.45 PCH1.A42 ; v1(191.11,177.55) 190.46,176.9 U24.4 ; 63.07,121.56 62.61,122.02 U28.2 ; 52.83,65.18 52.32,65.68 51.69,65.68 50.39,66.98 v3(50.24,66.98) 49.76,66.98 49.02,66.24 49.02,64.59 49.35,64.26 v3(50.22,64.26) ; C638.2 17.2,9.92 17.2,8.05 F_PANEL.8 ; M2_2.57 v1(98.07,18.92) ; M2_2.75 v1(101.02,23.42) ; M2_2.33 v1(98.14,12.92) ; v1(153.11,235.69) 153.21,235.59 HDMI1.17 ; C355.1 67.74,124.33 68.05,124.64 v1(68.05,124.84) ; M2_2.21 98.18,9.92 v1(97.97,10.13) ; CODEC.7 18.39,214.96 v1(18.54,215.11) ; R532.2 38.3,48.13 37.97,48.46 v1(37.97,48.87) ; v5(118.97,133.4) 119.9,133.4 CPU1.AR16 ; v5(103.81,155.77) 103.81,155.79 103.82,155.8 ; HDMI2.11 v1(125.1,235.89) ; HDMI2.2 v1(120.6,235.89) ; HDMI1.8 v1(148.71,235.65) ; v5(103.81,144.83) CPU1.AD1 ; 30.91,111 31.85,111.94 32.05,111.94 32.44,112.32 M2_1.57 ; 42.75,123.22 42.19,122.65 M2_1.18 ; 46.58,114.55 45.34,114.55 44.94,114.15 M2_1.7 ; 127.76,162.66 v5(128.65,162.66) ; M2_2.73 100.44,22.92 100.75,22.62 v1(101.03,22.62) ; M2_2.51 v1(98.07,17.42) ; M2_1.33 38.44,114.24 38.15,114.53 37.16,114.53 36.94,114.3 M2_1.39 36.94,112.17 36.19,111.43 ; PCH1.A18 59.29,64.81 v3(58.55,65.56) ; R431.2 191.11,64.24 v1(191.8,63.55) ; v5(123.54,164.85) 123.65,164.74 CPU1.C22 ; HDMI1.5 v1(147.21,235.65) ; v5(115.87,162.66) 116.79,162.66 CPU1.E15 117.7,162.66 117.7,163.57 CPU1.C16 ; 124.1,157.18 125.02,157.18 CPU1.K24 ; 30.63,111.3 30.94,111.61 M2_1.63 ; 125.93,159 v5(126.85,159) ; v5(128.65,164.49) 127.76,164.49 ; v3(73.76,44.6) 73.1,45.26 PCH1.AY45 ; M2_2.45 v1(98.15,15.92) ; M2_2.39 v1(98.12,14.42) ; HDMI1.11 v1(150.21,235.65) ; HDMI2.17 v1(128.1,235.89) ; U27.4 v1(192.51,141.42) ; HDMI1.2 v1(145.71,235.65) ; HDMI2.8 v1(123.6,235.89) ; 29.44,111.28 M2_1.69 ; HDMI2.5 v1(122.1,235.89)
  TOP w0.305: CPU1.AF1 103.85,143 v5(103.8,143.05) ; CPU1.B24 125.55,165.03 125.55,165.78 CPU1.A24 125.58,165.97 125.58,167.13 v5(125.88,167.44) ; CPU1.P39 v5(140.93,152.6) ; CPU1.AT13 117.53,132.86 116.79,132.86 CPU1.AT12 ; 127.76,164.49 CPU1.B26 ; v5(125.93,156.29) 126.39,155.83 CPU1.M25 v5(125.93,155.35) ; CPU1.H24 125.93,159 ; v5(105.81,159) CPU1.J3 ; CPU1.K22 124.1,157.18 ; CPU1.AF5 107.95,143.15 107.95,143.77 CPU1.AE5 ; CPU1.M12 v5(114.04,156.26) CPU1.L11 ; U26.9 71.6,147.32 72.1,146.82 U26.5 ; v5(135.45,153.52) CPU1.N33 ; v5(129.59,159) CPU1.H28 ; CPU1.AA8 v1(111.58,147.57) ; v5(126.85,157.18) CPU1.K26 ; CPU1.AJ32 v5(135.45,139.8) ; CPU1.H35 v5(137.27,158.09) CPU1.J34 v5(136.36,157.18) CPU1.K33 v5(135.45,156.26) ; v5(135.45,159) CPU1.G33 ; v3(57,47.42) 57.15,47.42 PCH1.AT15 ; CPU1.H21 122.73,159.44 v5(122.3,159) ; v5(140.93,150.77) CPU1.T39 ; v5(135.45,144.37) CPU1.AC33 v5(136.36,144.37) CPU1.AC34 ; v5(137.27,148.95) CPU1.V35 ; v5(135.45,160.83) CPU1.E33 ; CPU1.C37 v5(139.1,162.66) ; v5(137.27,160.83) CPU1.E35 ; CPU1.AK9 v5(112.2,139.78) ; v5(140.93,158.09) CPU1.H39 ; CPU1.P37 v5(139.1,152.6) ; CPU1.D24 125.58,163.22 125.58,163.93 CPU1.C24 ; CPU1.G8 110.95,160.27 110.95,159.56 CPU1.H8 ; v5(122.27,155.35) CPU1.M21 ; v5(129.59,160.83) CPU1.F28 ; v5(140.93,148.95) CPU1.V39 ; CPU1.AL21 124.92,137.52 ; v5(111.3,143.46) CPU1.AE8 ; CPU1.M15 117.83,155.22 118.49,155.22 v5(118.62,155.35) CPU1.M17 ; v5(137.27,150.77) CPU1.T35 ; v5(131.42,162.66) CPU1.D30 ; v5(127.76,155.35) CPU1.M27 ; CPU1.AR17 CPU1.AR16 ; v5(133.62,160.83) CPU1.E31 ; CPU1.P35 v5(137.27,152.6) ; v5(129.59,164.49) CPU1.B28 ; v5(131.42,164.49) CPU1.B30 ; CPU1.K19 CPU1.J18 ; CPU1.K24 125.93,157.18 v5(125.96,157.18) ; v5(129.59,157.18) CPU1.K28 ; v5(108.56,148.95) CPU1.Y5 ; v5(139.1,156.26) CPU1.K37 ; v5(135.45,162.66) CPU1.C33 ; v5(139.1,148.95) CPU1.V37 ; v5(140.93,154.43) CPU1.M39 ; CPU1.AB39 141.88,146.24 v5(141.88,146.61) ; v5(120.44,155.35) CPU1.M19 ; v5(129.59,162.66) CPU1.D28 ; v5(131.42,159) CPU1.H30 ; v5(126.85,159) CPU1.H26 ; CPU1.K17 CPU1.J16 ; PCH1.AV17 58.93,46.31 v3(59.34,45.9) 59.7,45.55 PCH1.AW19 ; v5(131.42,157.18) CPU1.K30 ; 124.47,137.97 v5(124.47,137.97) ; v5(131.42,160.83) CPU1.F30 ; v5(129.59,155.35) CPU1.M29 ; v5(139.1,154.43) CPU1.M37 ; v5(139.1,150.77) CPU1.T37 ; v5(135.45,148.03) CPU1.W33 ; v5(134.53,155.35) CPU1.L32 ; v5(124.1,155.35) CPU1.M23 ; v5(139.1,158.09) CPU1.H37 ; v5(137.27,156.26) CPU1.K35 ; v5(138.19,148.03) CPU1.Y35 ; v5(133.62,162.66) CPU1.C31 ; v5(137.27,162.66) CPU1.C35 ; v5(137.27,154.43) CPU1.M35 ; v5(140.93,156.26) CPU1.K39 ; CPU1.AA33 v5(135.45,146.2) ; v5(133.62,159) CPU1.G31 ; v5(140.02,148.03) CPU1.Y37
  TOP w0.33: CPU1.A11 113.64,165.81 113.64,165.62 114.04,165.22 114.04,164.71 114.03,164.69 v5(114.03,164.5)
  TOP w0.356: CPU1.AN1 v5(103.78,136.6) ; CPU1.AG3 v5(105.81,141.63) CPU1.AG2 ; CPU1.AH5 v5(107.64,140.72) ; CPU1.AM24 v5(128.13,137.06) ; v3(133.62,136.12) 133.16,136.58 CPU1.AM30 ; v3(128.73,128.65) 128.59,128.79 CPU1.AY25 ; CPU1.AL5 v5(107.64,138) CPU1.AM5 ; v5(129.01,132.49) 129.48,132.94 129.49,132.94 ; CPU1.AT5 v5(107.64,134.32) CPU1.AR5 ; v5(130.87,137.06) CPU1.AM27 130.32,136.5 130.32,135.79 CPU1.AN27 130.44,135.69 v5(130.91,135.23) 130.44,134.77 CPU1.AP27 130.32,134.67 130.32,133.96 130.42,133.86 CPU1.AR27 130.33,133.77 130.33,133.03 CPU1.AT27 130.42,132.92 v5(130.91,132.49) 131.33,132.92 CPU1.AT28 ; v1(101.65,89.05) 101.68,89.08 101.68,89.8 C405.2 C406.2 ; CPU1.AT34 CPU1.AU34 136.82,132 v5(137.25,131.57) 136.82,131.14 CPU1.AV34 CPU1.AW34 136.82,129.64 v5(136.92,129.54) ; CPU1.J18 v5(119.53,159) ; CPU1.K15 v5(116.79,158.09) CPU1.K14 ; CPU1.AR3 v5(105.81,134.32) CPU1.AR2 ; CPU1.AD33 v5(136.36,143.46) CPU1.AE33 ; CPU1.AE3 v5(105.81,144.35) ; CPU1.C12 114.47,164.03 v5(114.03,164.5) ; CPU1.AR32 v5(134.54,133.4) ; v5(134.54,133.4) CPU1.AR31 ; v5(134.54,133.4) 134.08,132.94 CPU1.AT31 ; C399.2 172.5,92.15 DIMM2.127 ; v5(103.81,161.29) CPU1.F1 ; CPU1.AL24 v5(128.13,137.97) ; CPU1.AM37 v5(140.03,136.12) 140.48,136.57 CPU1.AM38 ; v5(123.56,137.06) CPU1.AM19 123.1,136.58 v5(122.67,136.14) 123.1,135.71 CPU1.AN19 ; v5(108.56,139.8) CPU1.AK6 ; CPU1.A13 115.42,166.49 v5(115.49,166.57) ; CPU1.AP40 v5(142.96,134.77) ; CPU1.E17 119.08,162.2 v5(119.52,162.64) ; CPU1.AT12 116.7,132.97 v5(116.24,133.4) CPU1.AT11 ; v5(138.75,129.54) 138.65,129.64 CPU1.AW36 ; CPU1.AN4 107.16,136.6 v5(106.73,136.12) ; CPU1.AR21 v5(125.36,133.4) ; CPU1.AL3 106.3,138.43 v5(106.73,138) 107.16,138.43 CPU1.AL4 ; v5(139.1,138) 139.54,138.43 CPU1.AK37 ; v5(139.1,138) CPU1.AK36 ; v5(139.1,138) 138.65,137.54 CPU1.AL36 ; CPU1.AM33 v5(135.45,136.12) 134.99,136.58 CPU1.AM32 ; CPU1.AN9 v5(112.22,136.12) ; CPU1.AK17 v5(120.82,138.89) ; DIMM2.139 162.55,90.77 C414.2 ; C402.2 96.88,89.03 DIMM1.80 95.55,88.28 95.55,89.62 C416.2 ; DIMM2.121 176.95,90.59 C400.2 ; v1(123.88,101.8) 123.36,101.29 C391.2 ; CPU1.AJ8 v5(111.3,139.8) ; R376.2 165.2,88.63 DIMM1.14 166.37,88.53 C401.2 ; v5(108.56,132.46) 108.13,132.03 CPU1.AV5 CPU1.AW5 ; CPU1.AN7 v5(110.39,136.12) ; v5(119.07,166.52) CPU1.A17 ; v5(115.87,160.83) CPU1.G13 ; v5(129.94,138.87) CPU1.AK26 ; v5(127.76,161.75) 127.76,161.75 CPU1.F26 ; CPU1.AP11 v5(115.33,134.32) CPU1.AR11 ; CPU1.AN11 v5(115.33,136.14) CPU1.AM11 ; v5(112.2,139.78) 112.64,139.34 CPU1.AK10 v5(113.13,138.89) ; CPU1.AD40 v5(142.96,143.92) ; CPU1.AK40 v5(142.96,138.43) ; CPU1.AT13 CPU1.AT14 118.53,132.97 v5(118.97,133.4) CPU1.AR14 ; v5(129.03,138.87) CPU1.AK25 ; CPU1.W3 v5(105.81,149.86) ; v5(108.56,162.66) CPU1.E6 ; CPU1.AJ31 v5(134.53,139.8) ; DIMM2.133 167.21,92.48 168.88,90.81 C398.2 ; 129.49,132.94 v3(129.06,133.38) 128.63,132.94 CPU1.AT25 CPU1.AT24 127.52,133.1 126.91,133.1 CPU1.AT23 ; 129.49,132.94 CPU1.AT26 ; v5(135.09,129.54) 134.99,129.64 CPU1.AW32 ; CPU1.L32 v5(135.45,156.26) ; CPU1.AP24 v5(127.22,135.23) ; CPU1.AP24 v5(128.13,134.32) CPU1.AR24 ; CPU1.AP24 v5(128.13,135.23) CPU1.AN24 ; CPU1.AR1 v5(103.78,134.77) ; CPU1.AT37 139.56,132.92 ; 139.56,132.92 v5(139.1,132.46) 138.65,132.92 CPU1.AT36 ; 139.56,132.92 v5(140.02,132.46) 140.48,132.92 CPU1.AT38 140.48,132.97 v5(140.93,132.51) 141.36,132.94 CPU1.AT39 ; v5(115.87,157.18) CPU1.L13 ; CPU1.AC34 137.02,145.03 137.53,145.03 ; CPU1.AV26 129.05,131.57 v5(129.01,131.57) 128.59,132 CPU1.AU25 ; v5(137.27,139.8) CPU1.AJ34 ; C407.2 104.5,89.38 v1(104.06,88.95) ; CPU1.P1 103.88,153.97 v5(103.81,153.9) ; C412.2 C413.2 126.59,89.82 v1(128.4,88.01) ; CPU1.AM36 138.65,136.58 v5(139.1,136.12) CPU1.AN36 ; v5(106.73,134.32) CPU1.AR4 ; v5(105.81,160.83) CPU1.G3 ; C404.2 C403.2 98.61,89.82 v1(97.87,89.08) ; CPU1.AD36 v5(139.1,143.46) CPU1.AE36 ; CPU1.K7 v5(109.47,157.18) CPU1.L6 ; v5(103.73,138.43) CPU1.AL1 CPU1.AL2 ; v5(113.13,136.12) 112.67,136.58 CPU1.AN10 v5(112.22,137.06) ; CPU1.AN30 133.19,135.69 v5(132.7,135.23) CPU1.AP30 CPU1.AR30 ; CPU1.AN5 v5(107.64,136.12) CPU1.AP5 ; v5(103.81,157.63) CPU1.K1 ; CPU1.AY9 v5(111.76,129.41) ; CPU1.AH38 140.45,140.26 v5(140.02,139.83) CPU1.AH37 ; 107.17,163.12 106.74,163.58 v5(106.75,163.58) ; CPU1.G11 v5(113.13,159.92) ; v5(113.1,134.32) CPU1.AT10 ; CPU1.AD37 v5(140.02,143.46) ; v5(123.19,162.66) CPU1.E21 ; CPU1.AU30 133.16,132 v5(133.59,131.57) 133.16,131.14 CPU1.AV30 CPU1.AW30 CPU1.AY30 133.16,128.59 v5(133.35,128.4) ; CPU1.M1 103.82,155.8 ; CPU1.J12 v5(114.96,159) ; CPU1.E23 124.56,162.2 v5(125.02,162.66) 125.47,163.12 CPU1.D24 ; v5(142.96,136.6) CPU1.AM40 CPU1.AM39 ; v5(105.64,147.57) CPU1.AA3 ; v5(133.62,137.06) CPU1.AM31 ; CPU1.AJ1 v5(103.78,140.26) ; CPU1.AT9 v5(111.3,133.4) CPU1.AT8 ; CPU1.AJ36 v5(139.1,139.83) CPU1.AH36 ; CPU1.AR36 v5(139.1,134.32) ; v5(139.1,134.32) CPU1.AP36 ; v5(139.1,134.32) CPU1.AP37 ; CPU1.J20 121.84,158.55 v5(122.3,159) ; CPU1.AY27 130.42,128.38 130.96,127.84 v5(130.96,127.81) ; CPU1.A7 v5(109.47,165.4) ; v5(106.73,160.83) CPU1.F4 ; v5(125.36,135.23) 125.82,135.69 CPU1.AN22 v5(126.3,136.14) CPU1.AN23 ; v5(131.77,138.87) CPU1.AK28 ; v5(119.9,136.14) CPU1.AN16 v5(119.9,135.23) ; v5(109.47,163.58) CPU1.D7 ; v5(106.73,159) CPU1.H4 ; CPU1.AG4 v5(106.7,141.63) ; CPU1.AF33 v5(136.36,142.54) ; v5(115.87,162.66) CPU1.E13 ; CPU1.AR19 v5(123.58,133.4) CPU1.AR20 ; v5(125.39,137.97) CPU1.AL21 ; CPU1.AK13 v5(117.16,138.89) ; CPU1.AK23 v5(126.3,138.89) ; v5(106.73,157.18) CPU1.K4 ; v5(117.24,166.52) CPU1.A15 ; v5(142.96,140.26) CPU1.AH40 ; CPU1.AR35 v5(137.27,134.32) CPU1.AR34 ; v5(121.38,160.83) CPU1.G19 ; v5(132.68,138.87) CPU1.AK29 ; CPU1.AF40 v5(142.96,142.09) ; CPU1.C5 v5(107.67,164.49) ; v5(108.56,149.86) CPU1.W6 ; v5(118.07,137.97) CPU1.AL14 v5(118.07,137.06) CPU1.AM14 ; CPU1.AY5 v5(108.1,129.54) ; CPU1.AW9 v5(111.3,131.57) CPU1.AV9 v5(111.3,132.49) ; CPU1.AF37 v5(139.1,141.63) ; v5(139.1,141.63) CPU1.AF36 ; v5(139.1,141.63) CPU1.AG36 ; v5(130.87,137.97) CPU1.AL27 ; CPU1.AJ35 v5(138.19,139.8) ; v5(109.47,151.69) CPU1.U6 ; v5(137.27,136.12) CPU1.AM34 ; CPU1.C20 121.74,164.11 v5(121.74,165) ; CPU1.J16 v5(117.72,158.99) ; v5(110.39,134.32) CPU1.AT7 ; CPU1.F22 v5(124.1,160.83) CPU1.G22 ; v5(121.76,133.4) CPU1.AR17 ; v5(121.76,133.4) CPU1.AT17 ; v5(121.76,133.4) CPU1.AR18 ; CPU1.AK16 v5(119.9,138.89) ; v5(112.22,159) CPU1.J10 ; CPU1.AK5 v5(107.64,139.8) CPU1.AJ5 ; v5(110.39,139.8) CPU1.AK8 ; CPU1.N6 v5(109.47,155.35) ; CPU1.R3 v5(105.81,153.52) ; CPU1.AD39 141.39,143.92 140.97,143.5 v5(140.93,143.46) 140.89,143.5 140.48,143.92 CPU1.AD38 ; v5(138.19,136.12) CPU1.AM35 ; v5(117.72,160.85) CPU1.G15 ; v5(119.53,164.49) CPU1.C18 ; CPU1.AN14 118.54,135.69 v3(118.97,135.25) 118.53,134.81 CPU1.AP14 ; CPU1.AJ33 v5(136.36,139.8) ; CPU1.AY7 v5(109.93,129.54) ; v5(106.73,139.8) CPU1.AJ4 ; C392.2 116.38,101.4 116.51,101.52 v1(116.51,102.08) 116.36,102.08 115.28,101.01 C393.2 ; v5(106.73,153.52) CPU1.P4 ; v5(131.76,131.57) CPU1.AV28 ; CPU1.AU4 v5(107.64,132.49) CPU1.AU5 ; v5(121.36,162.66) CPU1.E19 ; v5(106.73,155.35) CPU1.M4 ; v5(131.79,132.49) 132.25,132.93 CPU1.AT29 CPU1.AT30 ; CPU1.AN6 v5(109.47,136.12) ; CPU1.AN8 v5(111.3,136.12) ; CPU1.AK19 v5(122.64,138.89) ; CPU1.AK12 v5(116.24,138.89) ; CPU1.AT40 v5(142.96,132.94) ; 124.92,137.52 124.47,137.97 ; CPU1.AK15 v5(118.99,138.89) ; v5(119.53,160.83) CPU1.G17 ; v5(113.13,156.26) CPU1.L11 ; CPU1.J6 v5(109.47,159) ; CPU1.G6 v5(109.47,160.83) CPU1.F7 ; CPU1.AR33 135.9,133.83 v5(135.45,133.38) 135.01,132.94 CPU1.AT32 v5(135.47,132.48) ; CPU1.R6 v5(109.47,153.52) ; CPU1.AL30 v5(133.62,137.97) CPU1.AK30 ; v5(105.81,157.18) CPU1.L3 ; v5(120.82,137.06) CPU1.AM17 ; CPU1.AG33 v5(136.36,141.63) ; CPU1.N3 v5(105.81,155.35) ; CPU1.AL11 v5(115.33,137.06) ; CPU1.AK20 v5(123.56,138.89) ; CPU1.F10 v5(112.22,161.75) ; v5(110.39,141.63) CPU1.AH8 ; CPU1.AK18 v5(121.73,138.89)
  TOP w0.381: v1(58.72,127.69) 58.42,127.69 C349.2 ; C30.2 158.14,226.47 v1(157.94,226.67) ; C421.2 104.65,80.55 v1(105.82,81.71) ; C570.1 93.25,40.69 v1(91.77,40.69) ; CPU1.N8 v5(110.39,155.35) CPU1.M7 ; CPU1.AR23 CPU1.AR22 125.82,133.86 v5(125.36,133.4) ; CPU1.B6 108.56,165.4 v5(108.58,165.4) ; v1(72.52,10.97) 72.47,10.92 71.75,10.92 71.35,11.33 C635.2 ; C634.2 53.42,11.79 v3(53.85,12.22) ; v1(108.43,88.8) 107.64,89.59 R372.2 ; R466.2 37.46,55.35 v1(38.4,55.35) 39.3,55.35 R467.2 ; 72.57,48.74 72.9,48.41 v3(72.9,48.11) ; v1(186.26,122.45) 186.08,122.45 185.34,121.72 R334.1 ; v1(179.27,214.17) 178.86,214.59 R122.1 ; R630.2 74.14,32.64 v1(73.89,32.38) 73.38,31.88 RJ7.3 ; U12.8 v1(94.97,225.45) ; C10.2 R26.2 180.88,230.68 v1(181.64,229.92) ; v5(136.36,139.8) CPU1.AH33 ; C173.1 95.73,203.58 v1(96.11,203.2) ; v1(179.76,228.88) C22.2 R29.2 ; U9.8 v1(140.56,228.14) ; v1(11.68,189.31) 11.53,189.15 C227.2 ; v1(169.77,220.22) 170.43,220.88 C53.1 ; CPU1.AD6 CPU1.AE5 CPU1.AD4 v5(106.73,145.29) CPU1.AC3 ; CPU1.AD6 CPU1.AD7 CPU1.AD8 111.4,144.83 v5(111.81,144.42) ; CPU1.AD6 CPU1.AC6 CPU1.AB5 108.1,146.74 107.71,147.13 v5(107.65,147.13) ; v1(90.9,220.54) 90.88,220.55 U14.2 ; U10.8 136.12,228.22 v1(136.07,228.27) ; v1(35.69,36.09) 36.07,36.47 R603.2 ; C529.1 v1(196.42,53.94) ; U13.8 99.42,225.4 v1(99.72,225.7) ; CPU1.AT6 v3(109.47,133.4) CPU1.AU7 ; v3(69.34,148.08) 69.57,147.85 C309.2 ; v1(86.84,15.09) 86.56,15.37 C625.2 ; C394.2 50.39,99.24 49.89,98.73 v1(49.23,98.73) ; Q36.C v1(36.78,27.58) ; 168.63,230.25 168.71,230.33 C8.2 ; 168.63,230.25 v1(168.63,230.61) ; 168.63,230.25 168.63,229.49 168.98,229.14 U5.3 ; v5(104.21,164.26) 105.13,164.26 CPU1.C2 ; R339.1 58.4,119.38 57.87,118.85 v1(57.73,118.85) ; v5(115.89,163.56) 116.33,164 CPU1.C14 ; v1(113.87,88.98) 113.83,89.01 C397.2 114.66,89.85 114.69,89.82 C408.2 ; DIMM1.199 96.84,80.76 C422.2 ; C33.2 182.7,224.66 v1(182.19,224.16) ; CPU1.V8 110.89,150.27 v1(111.58,150.27) ; CPU1.AT15 119.43,132.94 v5(118.97,133.4) ; C395.2 52.68,99.36 53.34,98.7 v1(54.79,98.7) ; v1(97,203.2) 97,202.91 R198.2 R197.2 ; v1(56.03,118.44) 56.03,118.29 57,117.32 C379.1 ; v1(145.48,224.43) C46.2 ; R585.2 v1(86.49,40.11) C571.2 ; v1(114.58,43.87) 114.58,43.18 C559.1 113.69,43.51 v1(113.69,43.87) ; C28.2 177.23,224.75 176.66,225.32 v1(176.66,225.91) ; v5(110.39,164.49) CPU1.C8 ; v1(57.68,10.34) 57.1,10.34 56.17,9.4 C639.2 R758.1 ; CPU1.E11 113.61,162.2 v5(114.04,162.64) ; C621.2 34.44,24.51 v1(35.46,25.53) ; CPU1.H1 103.88,159.46 v5(103.81,159.53) ; v1(116.08,89.06) 116.81,89.8 C409.2 C410.2 C411.2 ; C418.2 C417.2 ; v1(99.8,42.34) 100.03,42.57 C556.1 ; R18.2 182.58,232.28 v1(182.4,232.46) ; v1(36.7,42.72) 36.7,43.15 C552.1 ; v1(181.08,233.32) 181.03,233.38 U2.2 ; v1(177.57,228.93) C9.2 ; CPU1.H9 v5(112.22,159) ; C47.2 151.96,223.43 151.74,223.65 v1(151.74,223.88) ; v5(140.93,161.75) CPU1.D39 CPU1.D40 ; v1(72.49,7.47) 72.11,7.09 72.11,6.4 71.68,5.97 C642.2 ; v1(91.8,42.04) 92.05,41.78 C562.2 C557.2 ; v1(187.86,119.71) 187.5,120.07 C364.1 ; v1(181.56,222.2) 182.72,222.2 C45.2 ; CPU1.AK7 v5(110.39,139.8) ; CPU1.U3 v5(106.73,151.69) CPU1.T4 CPU1.R3 ; R589.2 36.25,39.75 35.46,38.96 v1(35.18,38.96) ; v5(109.47,159) CPU1.H7 ; v1(169.06,233.5) 169.09,233.48 U1.2 ; CPU1.AG8 v5(110.39,141.63) ; CPU1.R33 v5(135.45,151.69) ; D19.8 v1(13.72,40.34) ; C590.2 12.8,33.53 v1(12.57,33.3) ; R711.2 43.66,24.21 v1(43.92,23.95) ; CPU1.C16 v5(118.62,164.49) ; CPU1.AF8 v5(111.3,143.46) ; v1(129.59,229.24) 129.21,229.62 C12.2 ; U4.8 v1(122.78,229.97) ; D20.8 v1(13.72,36.07) ; C613.2 106.83,25.55 v1(107.34,25.04) ; v1(140.11,164.67) 140.48,164.3 CPU1.B38 ; C428.2 v1(109.07,89.28) ; C626.2 88.67,15.81 v1(89.05,15.42) ; v1(117.98,29.34) 118.69,29.34 119,29.03 C605.2 ; CPU1.AH40 CPU1.AH39 ; CPU1.F40 142.3,160.35 v5(141.84,159.89) ; R450.2 R453.2 C516.1 v3(43.57,57.23) ; C420.2 101.83,80.93 v1(101.83,81.79) ; CPU1.G8 v5(110.39,160.83) ; 52.79,89.62 C415.2 ; CPU1.AG1 CPU1.AG2 ; R203.1 90.75,200.95 91.24,200.46 v1(91.24,198.86) ; CPU1.AC35 137.53,145.03 ; C42.2 R63.2 ; C29.2 R40.2 181.36,225.7 v1(181.51,225.55) ; CPU1.AG3 106.27,142.06 v5(106.7,141.63) ; CPU1.J32 v5(135.45,158.09) ; C356.2 57.76,123.7 v1(57.58,123.52) ; CPU1.R8 v1(111.63,153.06) ; v5(105.83,162.65) CPU1.E3 ; v5(139.1,162.66) CPU1.D37 ; Q34.C v1(35.79,30.18) ; DIMM1.239 57.61,81.53 C424.2 ; C606.2 R672.2 47.82,28.1 46.76,29.16 v1(46.53,29.16) ; C623.1 48.58,18.19 48.23,18.54 48.23,19.63 v1(48.08,19.79) ; v1(63.53,32.46) 63.53,31.54 R661.2 ; CPU1.AG5 v5(108.56,141.63) ; CPU1.D26 127.76,162.66 ; C622.2 54.12,22.92 v1(54.28,22.76) ; R380.2 59.78,90.72 R381.2 60.73,88.89 DIMM1.116 ; C637.2 71.75,9.65 72.47,9.65 v1(72.72,9.91) ; v1(8.97,30.99) 9.32,31.34 U39.2 ; C363.1 v1(183.31,121.53) ; C627.2 82.89,16.13 C628.2 83.16,16.4 83.16,17.02 v1(82.91,17.27) ; v1(177.57,226.44) C21.2 ; CPU1.U33 v5(135.45,149.86) ; v5(140.02,161.75) CPU1.E37 ; C43.2 v1(192.69,223.02) ; CPU1.C10 v5(112.22,163.58) ; CPU1.E9 v5(112.22,161.75) ; U3.8 v1(118.72,230.12) ; R465.2 v1(35.1,55.65)
  TOP w0.406: C142.2 71.86,207.16 v1(72.47,206.55) 72.47,206.53 73,207.06 C143.2 ; v1(76.96,206.48) 76.68,206.76 C146.2 ; v1(76.63,201.19) 76.63,201.52 76.17,201.99 U20.3 ; v1(83.39,212.62) 83.67,212.9 C97.1 ; 54.53,42.06 v3(53.85,41.38) ; C141.2 70.59,205.87 v1(70,205.28) 69.44,205.84 C140.2 ; U17.2 75.29,210.31 v1(75.06,210.08) ; v1(59.31,35.08) 59.23,35.15 C584.2 ; v1(89,65.48) 88.93,65.41 R430.2 ; R256.2 R258.2 v1(72.26,182.5) ; C553.1 38.46,43.33 v1(38.46,42.67) ; R499.2 35.48,52.71 v1(35.41,52.63) ; QN36.2 45.44,17.45 v1(45.44,18.31) 45.44,20.49 QN34.2 ; v1(83.59,67.49) 83.79,67.69 R417.2 ; v1(40.49,52.22) 40,52.71 C530.2 ; R252.2 v1(72.26,184.78) ; R257.2 v1(69.72,182.5) ; C120.1 v1(68.73,211.84) ; C129.2 18.9,209.5 v1(19.15,209.25) ; C131.2 22.33,209.45 v1(22.48,209.3) ; R259.2 v1(69.72,181.36) ; R250.2 v1(72.26,185.93) ; v1(20.68,13.77) 20.68,12.16 D24.1 ; C145.2 75.41,207.04 v1(74.85,206.48) 74.27,207.06 C144.2 ; C574.2 v1(86.08,39.04) R590.2 ; R260.2 v1(72.26,181.36) ; v1(17.25,209.35) 17.5,209.6 R151.2 ; v1(66.7,37.59) R597.2 ; v1(62.89,209.91) 63.08,209.71 63.63,209.71 D9.P ; R452.2 89.56,59.18 v1(89.99,59.61) ; v1(86.08,49.89) 85.93,50.04 R515.2 ; v1(78.44,211.66) 78.84,212.06 D8.P ; U42.2 v1(8.92,17.65) ; v1(53.64,206.38) 53.64,206.35 53.51,206.22 C156.1 ; D10.P 68.34,210.49 v1(68.53,210.49) ; v1(152.35,226.09) 152.17,226.26 U11.2 ; U23.3 30.67,184.11 v1(31.01,183.77) ; R516.2 v1(88.95,50.04) ; C130.2 v1(21.18,209.27) ; v1(86.13,53.75) 85.85,53.47 R495.2 ; R502.2 81.84,52.32 v1(81.86,52.3) ; D7.P v1(82.52,212.55) ; v1(65.61,173.58) 65.84,173.36 C256.2 ; R679.2 75.26,27.57 v1(75.26,26.97) ; C587.2 50.5,33.05 v1(50.9,32.64) 51.49,32.64 52.15,33.31 C589.2 ; C36.2 v1(88.75,222.81) ; QN37.2 50.18,17.85 v1(50.11,17.92) ; R737.2 v1(75.74,16.13) ; R282.2 73.03,156.04 73.53,156.54 74.4,156.54 74.9,156.03 v1(74.9,155.02) ; v1(86,60.02) 85.7,60.33 R448.2 ; v1(14.12,209.3) 14.2,209.37 C128.2 ; C132.2 15.62,208.64 v1(15.62,207.8) ; C117.1 v1(73.1,211.91) ; C629.2 13.31,15.49 v1(13.61,15.8) ; U16.2 v1(61.57,215.93) ; R266.2 v1(72.26,177.93) ; v1(72.24,187.96) 72.49,188.21 R243.2 R242.2 ; C139.2 68.17,205.46 v1(68.1,205.38) ; R251.2 v1(69.72,184.78) ; U40.3 v1(20.62,22.28) ; C155.1 v1(48.62,207.24) ; U18.2 v1(70.92,210.11) ; v1(55.37,30.1) 54.71,30.77 C594.2 ; U8.2 v1(130.58,227.33) ; R245.2 v1(72.26,187.07)
  TOP w0.457: v1(14.4,75.41) 15.8,75.41 16.17,75.04 U30.3
  TOP w0.508: v1(66.9,11.61) 66.73,11.79 SPI_DEBUG.9 ; C396.2 26.99,98.65 26.62,98.27 v1(25.91,98.27) ; Q25.E v1(156.06,64.64) ; R135.1 176.33,212.85 v1(176.25,212.78) ; v1(175.49,208.13) 176.43,208.13 R166.1 ; v1(12.93,68.48) 12.3,68.48 C468.2 ; C225.2 41.38,188.17 v1(41.35,188.14) ; C425.2 58.76,80.61 60.45,82.3 DIMM1.235 ; R693.1 C609.1 139.09,28.34 v1(139.09,29.01) ; v1(144.81,26.39) 145.49,26.39 QN30.2 ; CPU1.A4 107.64,166.32 ; v1(14.33,203.56) 14.33,204.09 C157.2 15.67,204.72 v1(16.1,204.29) ; v1(113.03,214.38) 113.03,213.64 112.68,213.29 C121.2 ; C216.2 v1(22.2,192.66) ; v1(140.31,45.64) 140.31,45.42 140.79,44.94 C555.2 ; RT3.1 v1(191.62,149.86) ; R93.1 167.23,218.29 v1(166.73,217.78) 166.44,217.78 C85.1 ; C244.1 191.24,176.53 v1(191.11,176.66) ; C482.2 187.87,66.74 188.66,65.94 R427.2 188.79,65.66 v1(189.59,65.66) ; Q14.E 6.83,127.76 v1(6.55,127.48) ; C149.1 v1(173.71,207.14) R174.1 ; v1(57.12,103.23) 57.12,102.34 C390.2 ; v1(34.39,188.21) 33.98,188.63 C226.2 C219.2 ; C87.2 150.34,223.3 v1(150.34,223.65) ; U29.3 v1(184.85,116.45) ; C344.1 73.7,134.66 v1(73.71,134.67) ; v1(189,31.04) 188.47,30.51 C601.2 ; C494.2 6.99,67.38 v1(6.13,68.24) ; C77.2 v1(112.5,226.57) C86.2 ; C598.2 v1(162.28,29.49) ; Q10.C 38.03,205.9 v1(38.02,205.89) ; v1(134.39,175.46) C251.2 ; QN32.2 v1(159.8,27.24) ; v1(152.78,207.26) 152.78,208.99 153.47,209.68 C133.1 ; C257.2 72.52,172.21 v1(72.14,172.59) ; C361.2 53.95,123.52 54.84,124.41 v1(54.84,125.32) ; C123.1 173.02,212.75 v1(173.71,212.75) 174.4,212.75 R134.1 ; C204.2 33.59,195.39 PCIE1X.B4 ; U34.4 v1(178.45,58.74) ; v1(133.12,30.23) 132.9,30.45 R667.1 ; C110.2 110.11,214 v1(110.46,214.35) ; C2.2 192.2,235.08 v1(192.07,235.2) ; C367.1 R339.1 ; v1(163.2,198.98) 163.2,199.39 163.14,199.45 C188.1 ; SPIROM1.4 66.27,9.78 65.89,9.4 v1(65.89,9.07) ; C600.2 C604.2 103.68,29.34 v1(103.33,29.69) ; C19.2 v1(154.15,226.59) ; v1(23.65,207.39) 23.65,207.7 24.23,208.28 R161.2 24.61,207.37 v1(24.54,207.29) ; R216.2 93.55,198.56 v1(93.55,198.22) ; C474.2 v1(156.6,66.6) ; v1(48.08,192.07) 48.65,191.51 C218.1 ; C602.1 v1(130.37,31.3) ; Q17.E v1(7.54,123.14) ; Q16.E 52.6,127.3 v3(52.6,126.14) ; v1(157.4,199.49) 157.81,199.9 C187.1 ; C272.1 v1(163.98,159.58) ; C321.2 71.51,144.3 v1(71.55,144.35) ; v5(103.78,132.94) CPU1.AU1 ; C505.2 v1(132.31,60.71) ; v1(101.17,211.07) 101.37,211.28 C93.2 ; C550.2 v1(162.47,46.09) ; C169.1 v1(103.73,202.44) ; R393.2 179.58,78.45 v1(179.43,78.61) ; R460.1 v1(13.82,55.93) ; v1(98.15,36.96) 98.53,37.34 C579.1 ; v1(67.36,215.67) 67.64,215.39 C119.2 ; v1(122.59,175.39) C247.1 ; R394.2 4.67,80.01 v1(4.93,80.26) ; v1(110.01,25.07) 110.03,25.1 C611.2 R700.2 ; v1(155.45,70.74) 155.19,70.99 R404.1 ; 52.3,6.48 51.99,6.48 51.38,7.09 v1(51.38,7.57) ; v1(195.81,230.66) 195.52,230.95 C6.2 ; C548.1 96.44,46.96 v1(97.05,47.57) ; C593.2 90.91,31.62 v1(90.68,31.39) ; v1(46.51,215.52) 46.08,215.52 R118.2 45.49,214.33 46.41,214.33 47.27,215.19 v1(47.27,215.47) ; v1(170.48,211.79) 170.96,211.31 C127.2 ; C31.2 v1(128.85,224.21) ; v1(86,24.77) 85.45,25.32 C617.1 ; C41.2 185.52,223.15 v1(185.01,223.65) ; Q38.C 28.04,10.29 v1(28.93,11.18) ; v1(45.11,27.53) 45.11,26.9 C646.1 R712.1 ; v1(182.68,126.19) 183.33,126.84 QN13.2 ; 42.75,123.22 43.74,124.21 v1(45.8,124.21) ; RT1.1 v1(119.77,199.93) ; v1(60.38,120.47) 60.38,119.88 C370.1 ; v1(76.73,200.03) C186.2 ; v1(169.88,78.44) 169.24,79.07 C427.2 ; C177.1 57.96,202.31 v1(58.12,202.46) ; C296.2 v1(160.76,149.35) ; v3(75.37,148.02) 75.18,148.21 C305.2 ; R343.2 161.52,220.22 v1(162.15,220.85) ; Q20.E v1(186.07,115.84) ; Q33.E 96.52,30.28 v1(96.52,30.94) 95.14,30.94 R664.2 ; v1(49.35,184.96) 49.35,184.57 50.45,183.47 C233.2 ; C517.2 v1(121.7,58.36) ; C252.1 v1(137.35,175.36) ; v1(176.63,52.12) 176.63,52.78 C526.2 175.74,52.83 v1(175.74,52.2) ; PCIE16X.A12 20.86,185.58 C230.2 ; C358.2 51.54,123.65 52.5,124.61 ; v1(153.31,226.59) 153.09,226.82 C18.2 ; C559.1 113.86,42.46 C563.1 ; C179.2 45.75,202.06 v1(45.08,202.72) ; 52.5,124.61 v3(52.58,124.69) ; 52.5,124.61 52.5,123.39 C360.2 ; v1(165.18,225.27) 164.95,225.04 C37.1 ; C229.2 41.8,186.79 v1(41.73,186.72) ; v1(166.32,232.03) 165.62,232.73 C3.1 ; CPU1.AY3 v5(105.8,129.73) ; v1(142.72,46.48) 143.46,46.48 C539.2 143.74,45.75 v1(142.72,45.75) ; C532.2 v1(162.15,53.19) ; R482.2 177.9,53.16 v1(178.13,52.93) ; U36.8 R475.1 156.47,54.51 156.01,54.05 v1(156.01,53.52) ; v1(150.44,73.15) 150.32,73.28 C449.1 ; C1.2 167.39,232.03 v1(167.49,232.03) ; v1(175.23,77.47) C438.2 ; C480.2 v1(177.17,66.14) ; RJ5.3 v1(77.95,36.5) RJ6.3 ; v1(77.04,23.47) 76.56,23.95 C620.2 ; v1(91.57,25.65) 92.3,26.38 R709.2 C619.1 ; C264.1 v1(163.98,162.75) ; R30.2 133.07,224.41 v1(132.82,224.16) ; v1(63.53,32.46) 63.73,32.66 R628.2 ; C576.1 97.64,37.59 v1(97.51,37.47) ; C172.2 57.51,203.99 v1(57.51,204.42) ; C585.2 120.59,34.37 v1(121.31,34.37) ; R352.1 v1(182.42,110.86) ; Q31.E v1(138.28,46.99) ; C583.2 104.4,36.41 v1(104.55,36.26) ; v1(115.8,219.2) 114.21,219.2 113.89,219.52 QN5.2 ; v3(104.82,212.06) 104.26,211.51 U15.4 ; Q35.E v1(195.81,26.47) ; C271.1 v1(160.78,159.58) ; R238.2 v1(74.9,190.5) ; 83.25,41.94 83.25,42.37 v1(82.98,42.65) ; 83.25,41.94 C568.2 ; 83.25,41.94 C560.2 ; C263.1 v1(160.76,162.75) ; v1(189.76,70.82) 189.27,70.32 C467.2 ; v1(149.22,70) 149.55,70.33 C464.1 ; v1(8.69,135.08) 8.99,134.77 C346.1 ; C240.1 190.68,180.82 v1(191.16,180.34) ; QN39.2 v1(195.81,121.41) ; C182.1 183.66,201.77 v1(183.41,201.52) ; v1(48.69,194.59) 48.69,194.89 49.1,195.3 R226.2 ; R476.2 v1(128.97,55.58) ; v1(84.1,26.95) 83.69,26.95 83.16,26.42 C616.1 ; v1(52.63,15.47) 52.97,15.47 C624.1 ; v1(49.66,129.54) 49.12,129.01 Q15.E 49.12,123.67 49.76,123.03 C359.2 ; C492.1 143.48,63.91 v1(143.48,64.54) ; R235.2 R237.2 v1(75.44,191.64) ; C478.1 145.1,67.34 C476.1 ; C618.1 89.07,26.38 v1(89.56,26.87) ; v1(142.28,25.15) QN29.2 ; C558.2 v1(126.94,43.29) ; v1(193.14,147.83) 193.14,148.84 C300.1 ; QN11.2 8.85,148.27 v1(8.81,148.31) ; QN27.2 130.85,25.21 v1(130.23,24.59) ; C645.2 v1(178.75,30.26) ; C610.2 115.57,25.1 v1(115.67,24.99) ; C591.2 v1(103.61,33.27) ; R389.2 171.5,80.96 DIMM1.127 173.02,82.11 173.02,80.69 C429.2 ; QN14.S v1(186.39,128.78) ; C147.1 v1(115.01,207.52) ; v1(74.27,26.92) R718.2 ; v1(160.25,205.49) 160.53,205.49 C158.1 ; C16.2 v1(133.07,229.87) ; C232.2 11.4,182.93 v1(11.63,182.7) ; v1(55.47,103.25) 55.22,103.25 54.02,102.06 R365.2 ; L24.1 121.67,35.69 v1(121.77,35.79) ; C95.2 148.06,223.36 v1(148.06,223.62) ; C608.2 v1(103.23,28.19) ; R506.1 v1(179.3,53.16) ; C311.2 v1(163.3,145.8) ; v1(193.09,228.68) C13.2 C14.2 194.92,228.52 v1(195.5,227.94) ; C261.1 190.98,165.23 v1(191.72,164.49) ; v1(55.02,5.84) 55.73,5.13 C643.2 C640.2 ; R574.2 106.4,42.44 v1(106.55,42.6) ; v1(5.77,52.83) 4.09,52.83 3.69,53.23 R484.2 ; C318.2 72.54,144.32 v1(72.39,144.17) ; C222.1 v1(185.52,190.88) ; C210.1 94.46,193.89 95.11,193.24 v1(95.3,193.24) ; v1(120.29,26.8) 121.02,26.07 C615.2 ; QN28.2 136.17,25.43 v1(136.17,25.27) ; C509.2 v1(142.82,59.91) ; C599.2 v1(176.38,29.57) ; R124.2 v1(81.23,212.47) ; v1(131.67,48.92) 131.36,48.61 QN23.2 ; v1(161.32,65.53) Q24.E ; v1(5.77,80.24) 5.82,80.19 C442.2 ; C101.2 v1(119.1,212.72) ; C231.2 32.89,185.14 31.57,185.14 v1(31.14,185.57) ; C586.2 103.84,34.42 v1(103.68,34.26) ; v1(171.09,215.29) 171.12,215.27 C94.1 R116.1 ; v1(112.55,24.89) 112.24,25.2 C612.2 ; R513.1 v1(127.1,49.25) ; R575.2 v1(107.54,42.6) ; C217.2 v1(23.34,192.74) ; R63.2 v1(156.18,222.5) ; C445.1 v1(146.41,79.3) ; v1(161.01,62.1) 160.57,62.1 C493.1 ; v1(4.17,163.07) R280.1 ; R598.2 v1(66.7,37.59) ; v1(131.43,175.44) C250.2 ; v1(23.72,200.89) 23.34,200.5 C185.2 ; D23.1 12.97,9.46 14,8.43 v1(14,7.87) ; v1(5.66,69.85) U32.2 ; U41.3 52.56,20.56 v1(52.3,20.83) ; v1(55.55,120.09) 55.76,120.09 R337.1 ; Q13.E 7.04,131.41 v1(6.5,131.95) ; v1(6.05,28.8) C607.2 R673.2 ; v1(7.54,119.41) Q18.E ; v1(182.24,91.85) 182.88,91.21 R383.2 ; v1(144.73,215.76) QN9.2 ; v1(11.12,55.26) 11.35,55.04 C527.2 ; C389.2 189.64,102.97 v1(190.42,102.97) ; v1(97.05,34.34) 96.96,34.34 Q32.E ; C596.2 v1(134.26,29.59) ; v1(99.97,29.11) 100.28,29.11 100.63,29.46 C603.2 ; v1(79.17,32.46) 79.22,32.51 R633.2 ; R576.2 v1(108.69,42.67) ; v1(53.24,190.98) 53.07,190.98 R241.2 ; C176.2 v1(119.77,202.09) ; C525.2 v1(132.18,52.86) ; v1(139.55,58.42) 140.25,57.72 QN22.2 ; C350.1 v1(5.21,127.83) ; C276.2 v1(160.76,156.21) ; C280.2 v1(160.76,154.56) ; v1(185.89,235.08) C4.2 ; v1(14.93,61.44) C489.2 ; C554.2 136.24,44.93 v1(136.45,45.14) ; v1(41.07,214.25) 41.25,214.25 C100.2 ; v1(51.32,194.42) 51.32,195.42 C207.2 ; C515.2 v1(126.09,56.92) ; C105.2 v1(79.98,212.52) ; C535.1 v1(125.96,49.25) ; C5.2 v1(187.17,234.31) ; C246.1 v1(190.47,175.01) ; v1(160.25,203.2) 160.38,203.33 R185.1 ; C195.2 34.52,200.25 v1(34.92,199.85) ; D13.1 10.71,203.45 v1(10.59,203.33) ; U25.8 4.04,158.35 v3(4.7,157.69) ; C533.1 v1(163.3,53.19) ; C597.2 v1(135.33,29.62) ; QN18.2 v1(191.16,115.5) ; QN19.2 7.66,86.09 R384.1 7.66,87.49 v1(8.33,88.16) ; v1(59.18,202.72) R183.2 ; v1(193.22,116.2) 193.52,115.9 C381.1 ; v1(4.78,151.92) 4.9,151.8 R291.2 ; U33.4 12.88,67.1 v1(12.93,67.18) ; QN40.2 v1(190.79,50.93) ; R500.1 v1(131.06,51.69) ; C423.2 99.82,80.82 v1(99.82,81.76) ; C439.2 v1(176.96,77.67) ; Q26.E v1(168.5,65.02) ; v1(140.35,175.41) C253.1 ; C538.1 193.78,46.41 192.96,45.59 v1(192.66,45.59) ; R92.1 162.31,218.12 v1(162.31,217.63) 162.31,217.24 C92.1 ; C454.2 v1(162.52,70.64) ; v1(124.18,173.61) C248.1 ; C148.2 v1(120.42,207.52) ; Q8.C v1(38.03,212.6) ; C126.2 v1(101.8,218.16) ; C183.1 186.28,201.77 v1(186.46,201.96) ; C521.2 v1(140.72,56.74) ; v1(137.23,62.05) C496.2 ; v1(142.65,52.45) 142.81,52.29 C531.2 ; C506.2 133.45,60.68 v1(133.3,60.83) ; v1(143.32,175.41) C254.2 ; QN26.2 v1(163.57,30.16) ; C234.1 v1(180.19,182.37) ; C595.2 v1(140.82,31.24) ; QN21.2 v1(139.6,61.15) ; C202.2 v1(23.9,195.87) ; C636.2 v1(93.32,9.96) ; QN25.2 v1(103.16,46.91) ; v1(57.58,130.02) 57.58,130.28 QN12.2 ; C549.1 v1(99.54,46.96) ; QN15.2 v1(187.03,124.21) ; v1(25.63,206.5) 25.63,206.53 26.15,207.05 D12.P ; Q7.C v1(38.03,215.44) ; C448.1 150.32,74.42 v1(150.42,74.32) ; C588.2 v1(47.5,33.48) 47.35,33.32 C592.2 ; v1(69.72,185.67) 69.98,185.93 R249.2 R244.2 ; QN16.2 7.58,134.6 v1(7.14,134.16) ; C209.1 61.39,195.09 v1(61.39,196.09) 61.39,196.96 C201.1 ; C34.2 v1(194.77,224.69) ; C440.2 v1(178.36,77.7) ; R17.2 v1(190.6,234.26) ; C536.1 v1(139.29,51.38) ; C320.1 v1(192.6,145.38) ; v1(54.39,194.18) C208.2 ; R649.1 v1(146.43,31.24) ; C118.2 v1(63.73,214.91) ; C38.1 v1(168.38,225.22) ; C171.1 165.46,203.33 v1(165.84,202.95) 165.46,202.56 R202.1 ; C471.1 v1(151.04,67.6) ; QN31.2 v1(156.37,25.25) ; C122.2 R123.2 86.48,214.99 v1(86.33,215.14) ; C249.1 v1(127.1,175.49) ; v1(167.94,199.03) 167.79,199.03 167.33,199.5 C193.1 ; QN17.2 v1(189.88,115.5) ; v1(54.17,197.07) C203.2
  BOTTOM w0.254: v1(165.66,226.39) 165.66,226.61 SC7.2 ; v1(175.18,226.49) 174.95,226.49 SC8.2 ; 32.87,67.54 35.53,67.54 36.83,66.24 v1(41.61,66.24) v1(42.34,66.24) 43.13,66.24 v1(43.15,66.22) 43.41,66.22 44.37,65.25 47.93,65.25 49.66,66.98 v3(50.24,66.98) 50.62,66.98 51.33,66.27 51.33,65.05 51.08,64.8 v3(50.62,64.8) 50.62,64.67 v3(50.22,64.26) 50.22,64.16 v3(49.48,63.42) 48.95,62.89 v3(48.64,62.89) 37.95,62.89 37.58,62.53 32.71,62.53 32.15,63.09 v1(32.15,66.23) 32.15,66.82 32.87,67.54
  BOTTOM w0.305: v1(149.96,173.36) SC19.2 ; SC18.2 v1(148.82,173.38) ; SC16.2 v1(151.1,180.39) ; v1(147.42,173.56) 147.68,173.81 SC17.2
  BOTTOM w0.381: v1(129.59,229.24) 129.11,228.75 SC5.2 ; SC55.1 70.51,34.32 v1(70,33.81) ; SC28.2 111.93,149.92 v1(111.58,150.27) ; SC43.2 SC42.2 36.63,64.36 v1(36.3,64.36) ; SC57.2 55.42,30.15 v1(55.37,30.1) ; v1(171.6,234.39) 171.94,234.05 SC1.2 ; SC2.2 169.68,233.5 v1(169.06,233.5) ; v1(36.3,63.6) 35.54,63.6 SY1.4 ; SC58.2 v1(65.76,29.01) ; v1(31.01,119.46) 31.17,119.61 SC41.2 ; SC4.2 168.68,230.56 v1(168.63,230.61) ; v1(32.15,66.23) SY1.2
  BOTTOM w0.406: SC39.2 28.68,123.84 28.68,122.86 v1(29.35,122.19) ; SC15.2 62.5,210.29 v1(62.89,209.91) ; SC46.2 56.74,55.67 v3(56.74,56.18) ; SC56.2 57.99,32.98 v1(57.89,32.87)
  BOTTOM w0.508: SQ42.E v1(129.39,8.51) ; SC51.1 66.19,51.21 v3(66.4,51.41) ; v3(66.34,55.95) 66.34,56.95 SC45.2 65.63,56.54 v3(65.63,55.98) ; SC70.2 v1(111.23,7.75) ; v1(61.62,57.56) 61.62,58.08 SC44.2 ; SC49.2 66.12,52.71 v3(66.37,52.45) ; SC37.1 29.65,124.68 v1(30,124.33) 30.35,124.68 SC38.1 ; SC62.2 106.1,21.46 v1(105.59,20.96) ; SC3.2 v1(176.3,232.19) ; v1(45.8,124.21) 45.44,124.21 45,123.76 SC40.2 ; SC645.2 SR766.2 132.18,8.25 v1(131.93,8.51) ; v1(61.32,25.3) 60.46,25.3 SC59.2 ; SC47.2 65.6,54.84 v3(65.53,54.91) ; v1(16.87,6.5) 16.87,5.84 F_PANEL.5 ; SC63.2 v1(112.27,20.96) ; SC53.2 27.86,42.37 v1(28.04,42.19) ; SC52.1 72.11,48.07 v4(71.41,48.07) ; R598.2 v1(66.7,37.59) R597.2 ; SC54.2 26.62,41.68 26.62,40.39 v1(26.42,40.18) ; v1(111.35,22.48) 111.09,22.22 SC61.2 ; v1(105.56,15.57) 106.12,16.13 SC64.2 ; SC10.2 v1(147.52,226.92) ; SC60.2 111.23,23.37 v1(111.38,23.22) ; v1(50.14,53.34) 49.79,52.99 SC48.2 ; v1(130.4,11.05) SQ43.E ; v1(111.23,6.6) 110.48,6.6 SC71.2 ; SC69.2 v1(111.99,9.02)
  vias: v1(3.73,191.31) v1(3.73,190.58) v1(6.45,165.02) v1(6.45,164.26) v1(7.67,149.63) v1(8.13,149) v1(8.36,163.55) v1(8.36,162.79) v1(8.38,157.58) v1(8.38,156.77) v1(8.38,155.93) v1(8.86,149.38) v1(22,7.29) v1(22.2,6.55) v1(23.98,101.63) v1(24.61,103.84) v1(25.81,107.06) v1(26.31,107.62) v1(26.44,106.68) v1(28.3,24.46) v1(28.55,27.33) v1(31.55,103.96) v1(32.11,106.17) v1(32.99,175.87) v1(35.15,175.41) v1(37.57,106.81) v1(37.57,106.05) v1(41.94,6.15) v1(41.99,4.22) v1(42.82,183.18) v1(44.37,180.21) v1(44.48,178.82) v1(45.16,183.16) v1(45.36,200.43) v1(45.36,197.84) v1(45.64,180.67) v1(45.67,194.69) v1(45.75,192.15) v1(46.28,205.71) v1(46.66,210.67) v1(46.71,115.9) v1(47.42,116.18) v1(47.73,205.77) v1(47.96,198.4) v1(48.01,6.25) v1(48.59,200.53) v1(48.56,104.37) v1(48.69,5.54) v1(48.82,209.65) v1(48.95,90.7) v1(49.43,90.02) v1(49.5,205.66) v1(49.96,107.01) v1(50.11,104.75) v1(50.6,211.63) v1(50.98,205.79) v1(51.64,210.52) v1(51.77,143.94) v1(52.35,159.56) v1(52.35,156.77) v1(52.32,152.6) v1(52.37,164.95) v1(52.4,150.24) v1(52.4,148.01) v1(52.93,145.77) v1(53.42,142.72) v1(53.64,107.57) v1(54.58,143.66) v1(54.71,108.64) v1(54.84,156.67) v1(54.81,152.78) v1(54.81,147.98) v1(54.86,164.67) v1(54.89,159.64) v1(54.86,150.24) v1(55.09,146.41) v1(55.35,165.23) v1(55.42,169.47) v1(55.45,160.3) v1(55.45,154.43) v1(55.52,208.33) v1(55.52,206.86) v1(55.63,158.04) v1(55.7,151.79) v1(55.75,109.65) v1(56.13,145.69) v1(56.29,191.06) v1(56.31,147.98) v1(56.85,144.09) v1(57.02,190.91) v1(57.12,105.46) v1(57.56,166.32) v1(57.81,190.47) v1(57.78,165.02) v1(57.94,169.44) v1(57.89,160.15) v1(57.89,157.71) v1(57.89,154.48) v1(58.14,160.91) v1(58.12,151.87) v1(58.39,206.58) v1(58.45,204.65) v1(58.39,148.41) v1(58.45,145.67) v1(58.65,190.5) v1(58.72,155.75) v1(58.75,153.49) v1(59.03,170.59) v1(59.05,149.91) v1(59.26,173.28) v1(59.66,190.5) v1(59.97,166.32) v1(60.45,167.06) v1(60.55,160.83) v1(60.68,111.51) v1(60.83,161.52) v1(60.86,122.61) v1(61.16,155.75) v1(61.21,153.62) v1(61.34,174.04) v1(61.37,149.86) v1(61.54,175.51) v1(61.47,170.13) v1(61.72,115.77) v1(61.82,170.89) v1(62.56,116.54) v1(62.89,167.11) v1(63.02,162.84) v1(63.25,173.05) v1(63.25,161.52) v1(63.4,117.27) v1(63.75,121.77) v1(63.86,168.25) v1(63.96,175.92) v1(64.11,114.94) v1(64.16,220.47) v1(64.19,219.58) v1(64.31,170.74) v1(64.41,122.35) v1(64.77,163.02) v1(65.25,162.03) v1(65.96,137.8) v1(66.24,168.25) v1(66.93,138.48) v1(67.21,162.92) v1(67.34,139.14) v1(67.69,138.48) v1(67.82,203.89) v1(67.92,118.75) v1(68.1,139.14) v1(68.43,138.48) v1(68.83,139.14) v1(69.52,203.99) v1(70.51,71.75) v1(70.84,121.67) v1(70.84,72.47) v1(72.36,205.36) v1(73.38,124.21) v1(74.83,205.38) v1(76.02,157.86) v1(76.02,156.21) v1(78.21,154.66) v1(79.04,134.77) v1(79.22,129.01) v1(79.35,130.56) v1(79.45,156.34) v1(80.39,131.8) v1(80.7,194.34) v1(81.1,133.22) v1(81.31,155.04) v1(81.94,133.2) v1(82.09,194.34) v1(82.19,137.11) v1(82.27,135.64) v1(82.63,156.59) v1(83.08,194.39) v1(83.59,133.45) v1(84.73,194.46) v1(85.12,193.07) v1(86,135.79) v1(86.72,193.42) v1(87.2,215.72) v1(87.63,199.01) v1(88.44,138.25) v1(88.65,72.42) v1(88.8,199.09) v1(89.03,70.15) v1(89.61,196.52) v1(89.69,73.38) v1(90.53,70.21) v1(90.8,194.97) v1(91.19,16.64) v1(91.39,141.25) v1(91.47,214.3) v1(92.97,213.64) v1(93.65,143.48) v1(93.73,60.07) v1(94.74,60.07) v1(94.79,12.95) v1(94.92,15.49) v1(95.02,213.18) v1(95.12,215.21) v1(96.55,60.07) v1(96.72,185.5) v1(97.26,214.2) v1(97.56,60.07) v1(98.5,185.37) v1(98.58,60.07) v1(98.78,213.89) v1(99.14,197.74) v1(99.14,196.98) v1(99.14,196.22) v1(99.14,195.45) v1(99.9,198.5) v1(99.9,197.74) v1(99.9,196.98) v1(99.9,196.22) v1(99.9,195.45) v1(100.13,185.52) v1(101.6,69.8) v1(101.63,68.81) v1(101.65,72.49) v1(101.68,66.22) v1(101.88,185.47) v1(103.05,185.5) v1(103.07,3.68) v1(103.56,4.24) v1(106.02,180.85) v1(106.98,180.8) v1(108.58,222.66) v1(109.63,222.68) v1(112.62,195.2) v1(112.62,194.44) v1(112.62,193.68) v1(112.62,187.83) v1(112.62,187.07) v1(112.62,186.31) v1(112.62,185.55) v1(113.39,195.96) v1(113.39,195.2) v1(113.39,194.44) v1(113.39,193.68) v1(113.39,188.98) v1(113.39,187.83) v1(113.39,187.07) v1(113.39,186.31) v1(113.39,185.55) v1(113.74,47.57) v1(113.74,46.84) v1(114.63,67.13) v1(114.66,47.57) v1(114.66,46.84) v1(115.04,77.8) v1(115.42,67.82) v1(115.54,47.57) v1(115.54,46.84) v1(116.05,77.8) v1(116.31,67.82) v1(116.43,47.57) v1(116.43,46.84) v1(117.2,77.8) v1(117.45,67.82) v1(117.55,150.93) v1(117.55,150.14) v1(117.55,149.38) v1(117.58,148.39) v1(117.58,147.42) v1(117.55,146.56) v1(117.83,144.78) v1(118.19,218.59) v1(118.34,67.82) v1(118.47,77.8) v1(119.86,77.8) v1(120.52,218.74) v1(121.01,77.8) v1(122.02,77.8) v1(122.76,218.72) v1(123.42,208.92) v1(124.18,210.31) v1(125.15,152.58) v1(125.15,151.1) v1(125.15,149.76) v1(125.15,145.52) v1(125.15,143.87) v1(125.15,142.34) v1(125.25,218.87) v1(127.1,209.55) v1(129.54,152.53) v1(129.54,151.51) v1(129.54,150.44) v1(129.54,149.48) v1(129.54,148.41) v1(129.54,147.57) v1(129.54,146.48) v1(129.54,145.54) v1(129.54,144.63) v1(129.54,143.64) v1(129.54,142.52) v1(130.4,195.63) v1(130.4,194.87) v1(130.4,194.11) v1(130.4,193.34) v1(130.4,188.09) v1(130.4,187.32) v1(130.4,186.56) v1(130.4,185.8) v1(130.61,208.05) v1(131.17,195.63) v1(131.17,194.87) v1(131.17,194.11) v1(131.17,193.34) v1(131.17,188.09) v1(131.17,187.32) v1(131.17,186.56) v1(131.17,185.8) v1(131.29,188.98) v1(131.37,208.05) v1(132.16,216.43) v1(133.68,216.59) v1(134.19,67.99) v1(134.19,67.07) v1(134.19,66.17) v1(134.24,65.1) v1(135.99,216.41) v1(137.77,208.03) v1(138.25,215.87) v1(138.53,208.03) v1(140.21,69.16) v1(140.72,216.41) v1(140.94,69.16) v1(142.21,77.62) v1(142.21,76.5) v1(142.9,216.51) v1(142.98,77.62) v1(142.98,76.53) v1(143.56,59.51) v1(143.56,58.39) v1(143.79,76.53) v1(143.87,195.58) v1(144.25,198.63) v1(144.58,76.53) v1(145.14,194.56) v1(145.8,65.15) v1(146,62.66) v1(146.41,195.58) v1(146.63,65.13) v1(146.91,62.71) v1(147.83,65.13) v1(147.8,62.69) v1(148.54,63.2) v1(148.67,65.13) v1(149.4,63.2) v1(150.6,63.2) v1(151.41,48.84) v1(151.46,63.2) v1(152.27,48.87) v1(153.16,49.78) v1(153.16,48.9) v1(154.08,48.92) v1(154.97,49.81) v1(154.97,48.92) v1(156.64,60.81) v1(157.4,60.83) v1(158.95,60.83) v1(159.72,60.86) v1(160.53,60.83) v1(161.47,60.83) v1(171.96,191.44) v1(173.96,191.44) v1(174.47,182.5) v1(174.47,181.74) v1(174.6,164.59) v1(174.6,163.83) v1(174.6,146.3) v1(174.98,146.94) v1(175.23,182.5) v1(175.23,181.74) v1(175.36,164.59) v1(175.36,163.83) v1(175.36,146.3) v1(175.74,146.96) v1(176,182.5) v1(176,181.74) v1(176.12,164.59) v1(176.12,163.83) v1(176.12,146.3) v1(176.53,146.96) v1(176.76,182.5) v1(176.76,181.74) v1(176.89,164.59) v1(176.89,163.83) v1(176.89,146.3) v1(177.34,60.93) v1(177.77,181.74) v1(177.9,146.33) v1(178.03,163.83) v1(178.33,61.01) v1(178.79,146.3) v1(182.42,228.9) v1(182.4,227.94) v1(182.6,182.5) v1(182.6,181.74) v1(182.73,164.59) v1(182.73,163.83) v1(182.65,147.07) v1(182.65,146.3) v1(183.36,182.5) v1(183.36,181.74) v1(183.41,147.07) v1(183.41,146.3) v1(183.49,164.59) v1(183.49,163.83) v1(184.12,182.5) v1(184.12,181.74) v1(184.18,147.07) v1(184.18,146.3) v1(184.25,164.59) v1(184.25,163.83) v1(184.89,182.5) v1(184.89,181.74) v1(184.94,147.07) v1(184.94,146.3) v1(185.01,164.59) v1(185.01,163.83) v1(189.05,222.91) v1(190.63,222.91) v1(191.92,226.8) v1(191.95,225.32) v1(194.82,226.16) v1(195.78,136.63) v1(196.7,136.63) v3(4.7,156) v3(7.19,157.69) v3(7.19,156) v3(9.24,65.23) v3(9.24,62.54) v3(11.03,65.23) v3(11.03,62.54) v3(21.77,76.91) v3(21.87,79.07) v3(25.88,36.96) v3(26.26,39.24) v3(26.59,57.07) v3(28.27,57.3) v3(28.45,68.91) v3(28.45,66.52) v3(28.42,61.47) v3(28.5,64.06) v3(29.46,55.6) v3(29.59,60.02) v3(37.8,70.71) v3(37.8,69.19) v3(38.4,91.06) v3(38.38,88.52) v3(39.01,86.94) v3(39.27,68.05) v3(39.47,84.79) v3(40.13,70.13) v3(40.89,68.83) v3(41.53,68.83) v3(42.82,72.95) v3(43.31,73.48) v3(45.39,74.98) v3(47.14,74.85) v3(48.18,72.14) v3(48.26,72.87) v3(49.05,44.09) v3(49.28,74.07) v3(49.48,102.29) v3(49.73,44.12) v3(50.67,202.63) v3(50.67,200.44) v3(52.53,39.57) v3(52.86,202.63) v3(52.86,200.44) v3(52.91,63.55) v3(52.93,56.13) v3(53.04,61.35) v3(53.82,61.4) v3(54.51,57.37) v3(54.51,55.95) v3(55.07,50.24) v3(55.32,58.22) v3(55.27,57.37) v3(55.35,51.38) v3(55.47,59.44) v3(56.06,58.93) v3(57,62.36) v3(57,48.9) v3(57.84,69.16) v3(57.92,60.68) v3(58.52,66.78) v3(58.85,67.84) v3(58.86,56.43) v3(58.86,51.01) v3(59.03,62.28) v3(59.34,60.78) v3(59.64,56.41) v3(59.63,54.88) v3(59.63,51.01) v3(60.41,55.66) v3(60.41,54.88) v3(60.41,54.11) v3(60.35,49.28) v3(61.18,55.66) v3(61.18,54.88) v3(61.18,54.11) v3(61.93,72.92) v3(61.96,55.66) v3(61.96,54.11) v3(62.53,70.76) v3(62.73,55.66) v3(62.73,51.01) v3(62.76,60.78) v3(62.76,49.76) v3(62.76,46.66) v3(63.51,54.88) v3(63.78,49) v3(63.83,46.71) v3(63.8,45.95) v3(64.28,54.88) v3(64.29,53.34) v3(65.07,48.41) v3(65.13,46.76) v3(65.25,49.4) v3(65.58,50.07) v3(66.29,49.22) v3(66.47,59.18) v3(66.87,48.46) v3(67.03,58.24) v3(67.11,59.84) v3(67.65,47.41) v3(67.84,71.6) v3(67.87,52.53) v3(67.87,50.07) v3(68.2,60.99) v3(68.22,59.39) v3(68.5,73.1) v3(68.48,67.08) v3(68.53,57.37) v3(68.63,55.95) v3(68.63,54.91) v3(68.63,51.49) v3(68.58,49.22) v3(68.71,46.37) v3(68.94,69.9) v3(68.88,69.16) v3(69.21,48.18) v3(69.4,46.04) v3(69.6,70.89) v3(70.84,73.15) v3(70.92,66.7) v3(71.3,68.96) v3(72.36,149.86) v3(72.54,64.69) v3(73,149.86) v3(73.08,65.07) v3(73.14,42.19) v3(76.05,128.85) v3(77.37,72.8) v3(77.5,158.78) v3(77.88,129.84) v3(79.2,72.72) v3(79.3,136.4) v3(79.55,160.02) v3(79.76,158.52) v3(79.76,71.5) v3(81.33,136.91) v3(81.48,71.81) v3(81.79,159.97) v3(82.32,161.16) v3(83.13,72.03) v3(84.43,160.55) v3(84.76,162) v3(86.89,161.16) v3(87.78,162.41) v3(89.89,161.82) v3(90.12,163.37) v3(92.28,162.61) v3(92.66,163.98) v3(94.24,198.93) v3(94.21,155.04) v3(94.23,153.9) v3(94.92,165.28) v3(94.92,163.5) v3(96.21,197.82) v3(96.33,43.46) v3(96.33,41.37) v3(97.08,164.67) v3(97.26,166.34) v3(97.93,43.46) v3(97.93,41.37) v3(99.36,165.53) v3(103.84,167.21) v3(104.82,214.76) v3(105.21,165.99) v3(106.61,214.76) v3(106.61,212.06) v3(124.51,52.48) v3(125.63,54.45) v3(149.07,147.07) v3(150.98,147.07) v3(152.76,147.07) v3(155.96,147.04) v3(157.73,50.76) v3(157.73,49.06) v3(158.37,144.93) v3(160.22,50.76) v3(160.22,49.06) v3(160.58,142.75) v3(162.31,141.02) v3(162.98,213.3) v3(162.98,211.2) v3(162.98,209.11) v3(164.01,139.32) v3(165.07,213.3) v3(165.07,209.11) v3(165.73,137.59) v3(167.17,213.3) v3(167.17,211.2) v3(167.17,209.11) v3(167.59,135.41) v3(169.82,133.17) v3(174.37,128.09) v3(178.69,108.97) v3(178.74,103.1) v3(178.79,123.75) v3(178.79,119.91) v3(178.79,116.61) v3(178.79,113) v3(186.74,229.38) v3(186.74,227.89) v3(186.74,226.39) v3(188.24,229.38) v3(189.19,177.6) v3(189.74,229.38) v3(189.74,227.89) v3(189.74,226.39) v3(190.59,142.17) v4(51.73,57.08) v4(51.73,54.81) v4(51.72,52.54) v4(51.73,50.26) v4(51.72,47.99) v4(53.03,59.45) v4(58.1,63.55) v4(60.38,63.57) v4(62.65,63.56) v4(67.28,43.88) v4(71.42,59.43) v4(71.42,57.15) v4(71.41,54.88) v4(71.42,52.61) v4(71.42,50.32) v4(71.77,147.95) v5(108.56,136.12) v5(112.22,160.83) v5(112.22,159.92) v5(146.94,147.04) v6(187.43,194.69) v6(187.43,190.88) v6(189.71,194.69) v6(189.71,190.88) v6(192.38,194.69) v6(192.38,190.88) v6(194.51,190.93) v6(194.56,194.69)
