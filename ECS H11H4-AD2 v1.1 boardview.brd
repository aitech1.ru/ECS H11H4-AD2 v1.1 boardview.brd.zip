# Allegro board ECS H11H4-AD2 v1.1 boardview.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
M_DQS_B_N4: length 72.1
  TOP w0.089: v5(117.16,136.14) 117.16,135.83 117.35,135.64 117.56,135.64 CPU1.AN13
  GND w0.089: v5(117.16,136.14) 117.16,135.88 117.02,135.74 116.86,135.74 116.58,136.02 116.13,136.02 115.6,135.48 115.38,135.48 114.64,134.74 114.64,131.97 113.49,130.81 113.49,125.54 113.24,125.29 113.17,125.29
  GND w0.14: 113.17,125.29 104.21,116.33 104.21,115.15 101.21,112.16 arc(101.21,111.31) 102.05,111.31 104.33,113.59 arc(104.78,113.59) 104.78,113.14 100.26,108.62 100.26,103.55 96.62,99.91 96.62,97.94 95.76,97.08 95.76,95.68 96.7,94.74 96.7,93.8 95.84,92.95 95.84,91.71 92.76,88.63 92.76,87.42 92.47,87.12 91.87,87.12 91.69,87.3 91.69,87.85 DIMM1.84
M_DQS_B_N5: length 75.9
  TOP w0.089: CPU1.AR8 v5(111.3,135.23)
  GND w0.089: 103.13,129.01 103.13,129 ; v5(111.3,135.23) 110.85,134.77 110.85,134.14 110.12,133.41 110.12,133.08 109.68,132.64 109.12,132.64 108.75,133.01 106.69,133.01 106.61,133.01 104.37,130.77 104.37,130.33 104.02,129.98 104.02,129.9
  GND w0.14: 104.02,129.9 103.13,129.01 ; 103.13,129 96.29,122.17 96.29,120.47 94.54,118.72 94.54,109.72 89.85,105.03 arc(89.85,104.58) 90.29,104.58 93.47,107.76 arc(94.32,107.76) 94.32,106.91 86.87,99.46 86.87,97.67 85.85,96.66 85.85,95.9 86.87,94.88 86.87,93.84 85.93,92.9 85.93,91.71 83.01,88.78 83.01,87.26 82.7,86.96 82.7,86.23 DIMM1.93
M_DQS_B_N6: length 86.7
  TOP w0.089: CPU1.AM8 v5(111.3,137.97)
  GND w0.089: v5(111.3,137.97) 110.92,138.35 110.82,138.35 109.8,137.33 102.75,137.33 102.64,137.22 102.64,137.13 ; 100,134.5 99.99,134.49
  GND w0.14: DIMM1.102 74.04,87.79 74.04,87.35 73.81,87.12 73.41,87.12 72.92,87.6 72.92,89.04 75.97,92.09 75.97,93 76.89,93.91 76.89,94.76 75.95,95.7 75.95,96.81 76.96,97.83 76.96,98.54 74.78,100.73 74.78,110.4 arc(75.1,110.72) 75.41,110.4 75.41,106.82 arc(76.01,106.22) 76.61,106.82 76.61,112.46 82.02,117.88 83.38,117.88 99.99,134.49 ; 102.64,137.13 100,134.5
M_DQS_B_N7: length 91.2
  TOP w0.089: v5(108.56,142.54) 108.74,142.22 CPU1.AG6
  GND w0.089: 103.17,142.34 103.21,142.38 104.19,142.38 104.71,142.9 107,142.9 107.23,142.67 107.23,142.47 107.41,142.29 107.8,142.29 108.05,142.54 v5(108.56,142.54)
  GND w0.14: DIMM1.111 64.56,86.38 64.56,90.3 65.96,91.71 65.96,92.9 65.02,93.84 65.02,94.6 65.94,95.52 65.94,97 64.9,98.05 64.9,98.82 62.71,101 62.71,107.05 79.54,123.87 80.87,123.87 93.58,136.59 arc(93.76,137.01) 93.58,137.43 93.44,137.58 arc(93.44,138.03) 93.89,138.03 94.06,137.85 arc(94.46,137.69) 94.85,137.85 94.88,137.88 arc(95.05,138.3) 94.88,138.72 94.73,138.87 arc(94.73,139.32) 95.18,139.32 95.35,139.15 arc(95.75,138.98) 96.15,139.15 96.17,139.17 arc(96.35,139.6) 96.17,140.02 96.03,140.16 arc(96.03,140.61) 96.47,140.61 96.65,140.44 arc(97.04,140.28) 97.44,140.44 97.47,140.47 arc(97.64,140.89) 97.47,141.31 97.32,141.46 arc(97.23,141.68) 97.32,141.91 97.75,142.34 103.17,142.34
M_DQS_B_P0: length 93.4
  TOP w0.089: CPU1.AF35 138.11,142.09 138.19,142.17 v5(138.19,142.54)
  GND w0.089: v5(138.19,142.54) 138.31,142.79 138.36,142.84 141.4,142.84 141.65,143.08 142.34,143.08 142.56,143.3 143.74,143.3 144.06,143.62 144.54,143.62 144.54,143.59 144.55,143.59
  GND w0.14: 144.55,143.59 154.58,143.59 165.07,133.09 165.07,128.84 168.38,125.53 arc(168.38,125.08) 167.93,125.08 166.19,126.83 arc(165.34,126.83) 165.34,125.98 174.7,116.62 174.7,97.91 173.81,97.02 173.81,95.64 174.83,94.63 174.83,93.86 175.59,93.1 175.59,91.92 172.59,88.93 172.59,87.99 173.13,87.45 173.13,86.38 DIMM1.7
M_DQS_B_P1: length 87
  TOP w0.089: CPU1.AL33 136.01,137.63 136.01,137.81
  TOP w0.102: v5(135.45,137.97) 135.85,137.97 136.01,137.81
  GND w0.089: v5(135.45,137.97) 135.45,138.18 135.58,138.32 136.03,138.32 136.98,137.36 139.48,137.36 140.18,138.07 142.34,138.07 142.65,137.76 144.15,137.76 144.42,137.49 144.62,137.29 145.03,137.29 145.08,137.24
  GND w0.14: 145.08,137.24 152.35,137.24 156.64,132.95 156.64,124.55 157.56,123.63 157.56,121.49 159.08,119.96 159.08,117.88 159.54,117.42 163.59,117.42 167.69,113.32 167.69,106.63 164.57,103.5 164.57,102.91 arc(164.47,102.69) 164.25,102.59 163.71,102.59 arc(163.33,102.44) 163.17,102.06 163.17,102 arc(163.34,101.58) 163.77,101.4 164.53,101.4 arc(164.85,101.08) 164.53,100.77 163.77,100.77 arc(163.34,100.59) 163.17,100.17 163.17,100.11 arc(163.33,99.73) 163.71,99.57 164.25,99.57 arc(164.47,99.48) 164.57,99.25 164.57,97.73 163.8,96.97 163.8,95.86 164.69,94.97 164.69,93.85 165.66,92.89 165.66,91.59 164.77,90.7 164.77,87.62 164.25,87.1 163.96,87.1 163.73,87.33 163.73,87.89 DIMM1.16
M_DQS_B_P2: length 74.5
  TOP w0.089: v5(136.36,134.32) 136.36,134.68 136.27,134.77 CPU1.AP33
  GND w0.089: 143.18,131.5 143.18,131.56 141.3,133.43 137.23,133.43 136.36,134.3 v5(136.36,134.32)
  GND w0.14: 143.18,131.5 144.09,130.58 144.09,125.84 152.63,117.31 152.63,110.91 arc(152.31,110.59) 151.99,110.91 151.99,115.58 arc(151.4,116.18) 150.8,115.58 150.8,110.26 152.07,108.99 152.07,101.65 154.66,99.06 154.66,97.8 153.64,96.79 153.64,95.63 154.66,94.62 154.66,94.11 155.68,93.09 155.68,91.69 154.64,90.65 154.64,87.49 154.98,87.15 155.27,87.15 155.45,86.97 155.45,86.7 DIMM1.25
M_DQS_B_P3: length 71
  TOP w0.089: v5(130.91,136.14) CPU1.AN28
  GND w0.089: 138,126.09 138.04,126.12 138.04,126.83 135.69,129.18 135.69,129.95 135.55,130.09 135.22,130.09 134.02,131.29 134.02,131.75 133.75,132.02 133.55,132.02 132.94,132.63 132.94,133.9 131.26,135.58 131.26,135.8 130.92,136.14 v5(130.91,136.14)
  GND w0.14: 138,126.09 138,118.86 139.67,117.18 139.67,109.84 142.77,106.74 142.77,101.16 arc(142.46,100.84) 142.14,101.16 142.14,105.45 arc(141.54,106.05) 140.94,105.45 140.94,100.25 arc(141.12,99.82) 141.54,99.65 142.46,99.65 arc(142.68,99.56) 142.77,99.33 142.77,97.74 143.61,96.9 143.61,95.76 144.63,94.74 144.63,93.85 145.64,92.84 145.64,90.55 146.76,89.43 146.76,87.63 146.3,87.17 145.87,87.17 145.69,87.35 145.69,87.85 DIMM1.34
M_DQS_B_P4: length 72.2
  TOP w0.089: v5(117.14,135.23) 116.7,135.67 CPU1.AN12
  GND w0.089: 113.37,125.09 113.37,125.15 113.68,125.46 113.68,130.73 114.83,131.89 114.83,134.66 115.45,135.28 115.68,135.28 116.21,135.81 116.49,135.81 116.77,135.53 117.01,135.53 117.14,135.4 v5(117.14,135.23)
  GND w0.14: DIMM1.85 90.85,86.1 91.59,86.84 92.58,86.84 93.04,87.3 93.04,88.51 96.12,91.6 96.12,92.83 96.98,93.69 96.98,94.86 96.04,95.8 96.04,96.96 96.9,97.83 96.9,99.8 100.5,103.39 arc(100.53,103.44) 100.54,103.49 100.54,108.45 arc(100.55,108.5) 100.58,108.54 104.97,112.94 arc(104.97,113.78) 104.13,113.78 101.86,111.51 arc(101.41,111.51) 101.41,111.96 104.49,115.04 104.49,116.16 arc(104.5,116.21) 104.53,116.26 113.37,125.09
M_DQS_B_P5: length 76
  TOP w0.089: CPU1.AP8 v5(110.39,135.23)
  GND w0.089: 102.93,129.2 102.94,129.21 ; 103.83,130.1 103.87,130.1 104.18,130.41 104.18,130.85 104.24,130.91 106.53,133.2 106.76,133.2 108.83,133.2 109.2,132.83 109.61,132.83 109.93,133.15 109.93,134.57 110.39,135.02 v5(110.39,135.23)
  GND w0.14: DIMM1.94 81.84,87.4 82.15,87.1 82.45,87.1 82.73,87.38 82.73,88.9 85.65,91.82 85.65,93.01 86.59,93.95 86.59,94.77 85.57,95.78 85.57,96.77 86.59,97.79 86.59,99.58 94.12,107.11 arc(94.12,107.56) 93.67,107.56 90.49,104.38 arc(89.65,104.38) 89.65,105.23 94.26,109.84 94.26,118.84 96.01,120.59 96.01,122.29 102.93,129.2 ; 102.94,129.21 103.83,130.1
M_DQS_B_P6: length 86.7
  TOP w0.089: CPU1.AL8 v5(111.3,138.89)
  GND w0.089: 99.8,134.69 99.8,134.69 ; v5(111.3,138.89) 111.3,138.68 111.16,138.54 110.74,138.54 109.72,137.52 102.67,137.52 102.46,137.31 102.42,137.31
  GND w0.14: 102.42,137.31 99.8,134.69 ; 99.8,134.69 83.27,118.16 81.96,118.16 arc(81.91,118.15) 81.86,118.12 76.37,112.62 arc(76.34,112.58) 76.33,112.52 76.33,106.82 arc(76.01,106.5) 75.69,106.82 75.69,110.4 arc(75.1,111) 74.5,110.4 74.5,100.61 76.68,98.43 76.68,97.94 75.67,96.93 75.67,95.58 76.61,94.64 76.61,94.03 75.69,93.12 75.69,92.2 72.64,89.15 72.64,87.49 72.99,87.15 72.99,86.24 DIMM1.103
M_DQS_B_P7: length 91.3
  TOP w0.089: CPU1.AG7 v5(109.47,142.54)
  GND w0.089: 103.14,142.62 103.19,142.57 104.11,142.57 104.64,143.09 107.08,143.09 107.42,142.75 107.42,142.55 107.49,142.48 107.72,142.48 108.24,143 108.71,143 109.25,142.47 109.4,142.47 v5(109.47,142.54)
  GND w0.14: 103.14,142.62 97.64,142.62 97.12,142.11 arc(96.95,141.68) 97.12,141.26 97.27,141.11 arc(97.36,140.89) 97.27,140.67 97.24,140.64 arc(97.04,140.56) 96.84,140.64 96.67,140.81 arc(95.83,140.81) 95.83,139.97 95.97,139.82 arc(96.07,139.6) 95.97,139.37 95.95,139.35 arc(95.75,139.26) 95.55,139.35 95.38,139.52 arc(94.53,139.52) 94.53,138.67 94.68,138.53 arc(94.77,138.3) 94.68,138.08 94.65,138.05 arc(94.46,137.97) 94.26,138.05 94.08,138.22 arc(93.24,138.22) 93.24,137.38 93.39,137.23 arc(93.48,137.01) 93.39,136.78 80.75,124.15 79.42,124.15 62.43,107.17 62.43,100.89 64.62,98.7 64.62,97.93 65.66,96.89 65.66,95.63 64.74,94.72 64.74,93.73 65.68,92.79 65.68,91.82 64.28,90.41 64.28,88.15 64.12,88 DIMM1.112
M_MA_A0: length 45.9
  TOP w0.089: CPU1.AW15 119.45,130.2 119.45,129.87 119.11,129.53 119.11,128.97 121.01,127.08 121.01,125.91
  TOP w0.216: 121.01,125.91 121.01,113.92 112.22,105.14 arc(112.22,104.84) 112.52,104.84 113.25,105.58 arc(113.55,105.58) 113.55,105.28 111.22,102.95 110.03,102.95 108.66,101.58 108.66,97.56 107.84,96.74 DIMM2.188
M_MA_A1: length 48.3
  TOP w0.089: CPU1.AU18 122.77,131.45 122.77,130.84 122.99,130.61 122.99,129.94 123.62,129.31 123.62,126.44 124.74,125.32 124.74,125.17
  TOP w0.216: 124.74,125.17 124.74,111.28 124.05,110.59 124.05,108.11 121.47,105.52 arc(121.17,105.52) 121.17,105.82 121.27,105.92 arc(121.27,106.21) 120.97,106.21 118.74,103.99 117.37,103.99 114.55,101.17 114.55,99.36 115.06,98.86 115.06,97.61 115.58,97.09 115.58,95.36 114.84,94.62 DIMM2.181
M_MA_A2: length 46.1
  TOP w0.089: 124.33,125.17 124.33,125.3 123.37,126.26 123.37,129.26 122.76,129.87 122.76,130.52 122.52,130.76 122.52,131.31 122.31,131.52 121.78,131.52 CPU1.AU17
  TOP w0.216: DIMM2.61 114.84,97 114.63,97.21 114.63,98.48 113.89,99.21 113.89,101.07 117.31,104.48 118.68,104.48 121.89,107.69 arc(122.18,107.69) 122.18,107.39 121.6,106.81 arc(121.6,106.51) 121.9,106.51 123.65,108.26 123.65,110.77 124.33,111.46 124.33,125.17
M_MA_A3: length 48.3
  TOP w0.089: 125.12,125.16 125.12,125.37 123.88,126.62 123.88,129.36 123.23,130.01 123.23,130.78 123.16,130.85 123.16,131.06 CPU1.AV19
  TOP w0.216: 125.12,125.16 125.12,111 124.43,110.31 124.43,107.91 119.3,102.77 arc(119,102.77) 119,103.06 120.85,104.91 arc(120.85,105.21) 120.55,105.21 117.07,101.73 117.07,99.44 116.62,99 116.62,97.62 116.01,97.02 116.01,94.56 DIMM2.180
M_MA_A4: length 48.9
  TOP w0.089: CPU1.AT19 122.73,132.57 122.73,131.87 122.98,131.62 123.21,131.62 123.44,131.39 123.44,130.84 123.49,130.79 123.49,130.06 124.13,129.41 124.13,126.8 125.5,125.43 125.5,125.22
  TOP w0.216: 125.5,125.22 125.5,112.02 arc(125.71,111.81) 125.92,112.02 125.92,113.07 arc(126.13,113.28) 126.34,113.07 126.34,111.53 124.82,110.01 124.82,107.7 118.39,101.27 arc(118.09,101.27) 118.09,101.56 118.72,102.19 arc(118.72,102.49) 118.42,102.49 117.6,101.67 117.6,99.31 117.08,98.79 117.08,96.53 DIMM2.59
M_MA_A5: length 49.7
  TOP w0.089: CPU1.AU20 124.02,131.73 123.68,131.39 123.68,130.84 123.73,130.78 123.73,130.14 124.38,129.49 124.38,126.97 125.91,125.45 125.91,125.27
  TOP w0.216: DIMM2.58 118.14,98.48 118.14,100.46 125.22,107.54 125.22,109.83 126.75,111.35 126.75,118.81 arc(126.54,119.02) 126.33,118.81 126.33,113.9 arc(126.12,113.69) 125.91,113.9 125.91,125.27
M_MA_A6: length 48.2
  TOP w0.089: CPU1.AV20 124.02,130.16 124.64,129.54 124.64,127.15 126.31,125.48 126.31,125.27
  TOP w0.216: DIMM2.178 117.6,94.62 117.6,96.88 118.62,97.89 118.62,100.38 125.6,107.37 125.6,109.67 127.15,111.22 127.15,122.27 arc(126.94,122.48) 126.73,122.27 126.73,119.72 arc(126.52,119.51) 126.31,119.72 126.31,125.27
M_MA_A7: length 49.5
  TOP w0.089: CPU1.AU21 124.93,131.67 124.59,131.33 124.59,130.74 124.5,130.66 124.5,130.3 125.17,129.63 125.17,127.48 127.1,125.55 127.1,125.37
  TOP w0.216: DIMM2.56 119.84,100.46 125.2,105.82 arc(125.5,105.82) 125.5,105.53 124.76,104.79 arc(124.76,104.5) 125.06,104.5 125.8,105.23 arc(126.09,105.23) 126.09,104.93 125.36,104.2 arc(125.36,103.9) 125.65,103.9 126.69,104.93 arc(126.75,105.08) 126.69,105.23 126.36,105.55 126.36,109.3 126.87,109.8 127.46,109.8 127.94,110.29 127.94,125.09 arc(127.73,125.3) 127.52,125.09 127.52,124.26 arc(127.31,124.05) 127.1,124.26 127.1,125.37
M_MA_A8: length 47.6
  TOP w0.089: 126.72,125.4 126.72,125.5 124.92,127.3 124.92,129.57 124.25,130.23 124.25,130.74 124.35,130.84 124.35,131.57 124.45,131.66 124.45,132.51 CPU1.AT20
  TOP w0.216: 126.72,125.4 126.72,123.09 arc(126.91,122.89) 127.14,123.06 arc(127.14,123.08) 127.14,123.09 127.14,123.27 arc(127.19,123.39) 127.31,123.44 127.35,123.44 arc(127.5,123.38) 127.56,123.23 127.56,111.09 125.98,109.51 125.98,107.19 119.08,100.28 119.08,97.61 118.06,96.6 118.06,95.96 118.84,95.18 DIMM2.177
M_MA_A9: length 51.3
  TOP w0.089: 128.85,125.22 128.85,125.65 128.52,125.98 127.53,125.98 125.78,127.74 125.78,130.63 125.49,130.92 125.49,131.31 125.78,131.61 125.98,131.61 126.18,131.81 126.18,132.25 125.84,132.58 CPU1.AT22
  TOP w0.216: DIMM2.175 120.84,94.96 121.59,95.71 121.59,96.77 122.61,97.79 122.61,99.64 127.75,104.79 arc(128.05,104.79) 128.05,104.49 126.89,103.33 arc(126.89,103.03) 127.18,103.03 128.85,104.7 128.85,125.22
M_MA_A10: length 47.6
  TOP w0.089: CPU1.AY14 118.53,128.54 120.14,126.92 120.14,126.11
  TOP w0.216: DIMM2.70 105.84,99.9 119.3,113.36 119.3,118.87 arc(119.51,119.08) 119.72,118.87 119.72,114.38 arc(119.93,114.17) 120.14,114.38 120.14,126.11
M_MA_A11: length 49.2
  TOP w0.089: 128.45,125.27 128.04,125.68 127.41,125.68 125.48,127.61 125.48,130.54 125.28,130.73 125.29,131.72 125.49,131.91 125.73,131.91
  TOP w0.102: CPU1.AU22 125.73,131.91
  TOP w0.216: 128.45,125.27 128.45,105.82 127.86,105.23 127.54,105.23 124.64,102.33 arc(124.34,102.33) 124.34,102.62 124.96,103.24 arc(124.96,103.54) 124.66,103.54 123.66,102.54 arc(123.37,102.54) 123.37,102.84 124.39,103.86 arc(124.39,104.16) 124.1,104.16 120.71,100.77 120.71,96.41 DIMM2.55
M_MA_A12: length 47.1
  TOP w0.089: 129.24,125.22 129.24,125.78 128.73,126.29 127.66,126.29 126.09,127.86 126.09,130.87 CPU1.AV22
  TOP w0.216: DIMM2.174 122.05,94.59 122.05,96.57 123.04,97.56 123.04,99.39 126.31,102.66 arc(126.6,102.66) 126.6,102.36 125.32,101.08 arc(125.32,100.79) 125.62,100.79 129.24,104.4 129.24,125.22
M_MA_A13: length 44
  TOP w0.089: CPU1.AV12 116.07,130.72 115.72,130.72 114.86,129.86 114.86,129.51
  TOP w0.216: 114.86,129.51 114.86,113.08 100.66,98.89 100.66,97.71 99.84,96.89 DIMM2.196
M_MA_A14: length 47.8
  TOP w0.089: 130.07,125.25 130.07,126.24 129.41,126.9 127.91,126.9 127.25,127.56 127.25,128.73 127.1,128.88 127.1,130.77 CPU1.AV23
  TOP w0.216: 130.07,125.25 130.07,112.34 130.66,111.76 130.66,103.34 127.59,100.27 arc(127.29,100.27) 127.29,100.56 128.49,101.77 arc(128.49,102.06) 128.2,102.06 125.88,99.75 125.07,99.75 124.64,99.31 124.64,97.85 123.63,96.85 123.63,94.59 DIMM2.172
M_MA_A15: length 48.2
  TOP w0.089: CPU1.AU24 127.18,131.53 127.18,131.04 127.3,130.91 127.3,129.06 127.58,128.78 127.58,127.89 128.24,127.23 129.59,127.23 130.45,126.37 130.45,125.2
  TOP w0.216: 130.45,125.2 130.45,116.61 131.04,116.03 131.04,115.68 arc(130.98,115.53) 130.83,115.47 130.77,115.47 arc(130.56,115.26) 130.77,115.05 130.83,115.05 arc(131.04,114.84) 130.83,114.63 130.77,114.63 arc(130.56,114.42) 130.77,114.21 130.83,114.21 arc(131.04,114) 130.83,113.79 130.77,113.79 arc(130.56,113.58) 130.77,113.37 130.83,113.37 arc(130.98,113.31) 131.04,113.16 131.04,103.11 127.23,99.3 125.41,99.3 125.07,98.96 125.07,97.65 124.09,96.67 124.09,95.42 124.84,94.67 DIMM2.171
M_MA_B0: length 69.2
  TOP w0.102: CPU1.AL19 v5(122.64,137.97)
  GND w0.089: 122.81,127.43 122.81,129.24 122.91,129.34 122.91,134.66 123.11,134.87 123.11,137.16 122.78,137.74 v5(122.64,137.97)
  GND w0.178: 122.81,127.43 122.81,117.35 118.42,112.96 118.42,109.78 115.59,106.94 arc(115.28,106.94) 115.28,107.25 116.45,108.42 arc(116.45,108.72) 116.14,108.72 114.76,107.34 114.76,103.15 arc(114.69,103) 114.54,102.93 114.39,102.93 arc(114.17,102.72) 114.39,102.5 114.54,102.5 arc(114.76,102.29) 114.54,102.07 114.39,102.07 arc(114.17,101.86) 114.39,101.64 114.54,101.64 arc(114.76,101.42) 114.54,101.21 114.39,101.21 arc(114.17,100.99) 114.39,100.78 114.54,100.78 arc(114.69,100.71) 114.76,100.56 114.76,100.28 113.1,98.62 113.1,97.88 114.03,96.95 114.03,95.79 113.1,94.86 113.1,93.95 112.1,92.95 112.1,91.68 110.97,90.55 110.97,90.04 109.78,88.85 109.49,88.85 108.85,88.21 108.85,87.52 107.84,86.5 DIMM1.188
M_MA_B1: length 71
  TOP w0.089: v5(126.3,137.97) CPU1.AL22
  GND w0.089: v5(126.3,137.97) 126.73,137.54 126.73,136.01 126.56,135.64 126.56,132.01 126.7,131.88 126.7,129.62 126.14,129.06 126.14,127.51
  GND w0.178: 126.14,127.51 126.14,112.83 120.47,107.16 120.47,104.14 arc(120.24,103.91) 120.01,104.14 120.01,106.27 arc(119.79,106.5) 119.56,106.27 119.56,99.39 arc(119.33,99.16) 119.1,99.39 119.1,99.49 arc(118.87,99.72) 118.64,99.49 118.64,99.11 119.1,98.65 119.1,97.79 120.1,96.79 120.1,95.86 119.1,94.86 119.1,93.6 119.61,93.09 119.61,92.08 118.59,91.06 117.25,91.06 115.04,88.85 115.04,87.62 115.58,87.08 115.58,85.25 114.84,84.51 DIMM1.181
M_MA_B2: length 69.5
  TOP w0.102: CPU1.AM22 126.01,136.6 126.3,136.89 v5(126.3,137.06)
  GND w0.089: v5(126.3,137.06) 126.06,137.06 125.87,136.87 125.87,135.97 126.31,135.54 126.31,131.9 126.38,131.74 126.38,129.94 125.54,129.1 125.54,127.51
  GND w0.178: 125.54,127.51 125.54,113 119.1,106.56 119.1,100.46 arc(118.87,100.23) 118.64,100.46 118.64,105.49 arc(118.41,105.71) 118.19,105.49 118.19,98.91 118.58,98.52 118.58,97.67 119.58,96.67 119.58,95.98 118.59,95 118.59,93.98 117.58,92.96 117.58,92.1 114.58,89.1 114.58,86.36 DIMM1.61
M_MA_B3: length 67.9
  TOP w0.102: CPU1.AM23 v5(127.22,136.14)
  GND w0.089: v5(127.22,136.14) 127.22,135.84 126.79,135.41 126.79,135.08 126.82,135.06 126.82,132.16 127,131.98 127,129.23 127.25,128.98 127.25,128.19 126.62,127.56 126.62,127.51
  GND w0.178: DIMM1.180 116.05,84.41 116.05,87.08 116.58,87.61 116.58,88.79 118.39,90.6 118.9,90.6 120.1,91.81 120.1,93.2 120.62,93.73 120.62,95 121.58,95.95 121.58,96.64 120.58,97.64 120.58,98.58 120.01,99.14 120.01,103.2 arc(120.24,103.43) 120.47,103.2 120.47,99.44 arc(120.7,99.21) 120.93,99.44 120.93,106.97 126.62,112.66 126.62,127.51
M_MA_B4: length 67.8
  TOP w0.089: v5(127.24,134.32) 127.24,134.62 127.09,134.77 CPU1.AP23
  GND w0.089: 127.08,127.51 127.08,127.61 127.56,128.09 127.56,129.13 127.3,129.38 127.3,131.79 127.69,132.17 127.69,132.77 127.06,133.39 127.06,134.13 v5(127.24,134.32)
  GND w0.178: DIMM1.59 117.07,86.33 117.07,88.6 118.62,90.14 119.86,90.14 121.58,91.86 121.58,93.36 121.08,93.85 121.08,94.81 122.03,95.76 122.03,96.89 121.1,97.82 121.1,98.58 121.39,98.87 121.39,106.63 arc(121.62,106.86) 121.84,106.63 121.84,101.27 arc(122.07,101.04) 122.3,101.27 122.3,107.7 127.08,112.47 127.08,127.51
M_MA_B5: length 70.5
  TOP w0.102: v5(127.22,137.06) CPU1.AL23
  GND w0.089: v5(127.22,137.06) 127.67,136.6 127.67,134.15 127.33,133.8 127.33,133.5 127.94,132.89 127.94,132.03 127.61,131.7 127.61,129.55 127.86,129.29 127.86,127.94 127.56,127.64 127.56,127.51
  GND w0.178: 127.56,127.51 127.56,117.2 arc(127.79,116.97) 128.02,117.2 128.02,122.54 arc(128.03,122.62) 128.07,122.68 arc(128.24,122.77) 128.42,122.68 arc(128.46,122.62) 128.47,122.54 128.47,116.87 127.53,115.93 127.53,112.27 122.76,107.49 122.76,100.23 arc(122.53,100) 122.3,100.23 122.3,100.28 arc(122.07,100.51) 121.84,100.28 121.84,99.24 122.58,98.51 122.58,97.62 123.6,96.6 123.6,96 122.58,94.98 122.58,93.9 122.1,93.43 122.1,91.65 120.15,89.69 118.87,89.69 117.84,88.65 DIMM1.58
M_MA_B6: length 61.3
  TOP w0.089: CPU1.AW26 129.47,130.2 v3(129.01,129.74)
  GND w0.089: 128.57,127.64 128.57,127.86 129.13,128.42 129.13,129.62 v3(129.01,129.74)
  GND w0.178: DIMM1.178 117.84,84.96 118.03,85.15 118.03,86.44 119.1,87.5 119.1,88.39 119.48,88.77 120.64,88.77 121.47,89.61 121.66,89.61 124.1,92.06 124.1,93.27 124.58,93.74 124.58,94.85 125.58,95.85 125.58,96.59 124.61,97.55 124.61,102.01 123.7,102.92 123.7,105.82 arc(123.93,106.05) 124.16,105.82 124.16,103.46 arc(124.38,103.23) 124.61,103.46 124.61,104.55 125.27,105.21 127.89,105.21 128.47,105.79 128.47,115.56 129.44,116.52 129.44,124.76 128.57,125.63 128.57,127.64
M_MA_B7: length 59.6
  TOP w0.089: CPU1.AY26 129.5,129.27 129.74,129.03 v3(129.74,128.73)
  GND w0.089: 129.15,127.73 129.15,127.98 129.74,128.57 v3(129.74,128.73)
  GND w0.178: 129.15,127.73 129.15,125.69 129.92,124.92 129.92,116.36 128.93,115.37 128.93,105.61 128.02,104.7 125.45,104.7 125.07,104.32 125.07,99.9 arc(125.3,99.67) 125.53,99.9 125.53,103.76 arc(125.76,103.99) 125.98,103.76 125.98,99.59 125.07,98.68 125.07,97.79 126.09,96.77 126.09,95.67 125.07,94.66 125.07,93.98 125.58,93.47 125.58,91.69 125.32,91.44 124.13,91.44 121.84,89.15 121.66,89.15 120.51,88 DIMM1.56
M_MA_B8: length 63
  TOP w0.089: CPU1.AU26 129.5,132.05 v3(129.93,132.49)
  GND w0.089: v3(129.93,132.49) 129.49,132.04 129.49,131.39 128.85,130.76 128.85,130.56 128.17,129.87 128.17,127.79 128.07,127.69 128.07,127.51
  GND w0.178: 128.07,127.51 128.07,123.55 arc(128.3,123.32) 128.52,123.55 128.52,124.31 arc(128.75,124.54) 128.98,124.31 128.98,116.71 128.02,115.75 128.02,112.06 123.22,107.26 123.22,99.19 123.04,99.01 123.04,97.92 124.05,96.9 124.05,95.81 123.04,94.8 123.04,93.72 123.65,93.12 123.65,92.25 121.57,90.17 121.39,90.17 120.45,89.23 119.08,89.23 118.58,88.73 118.58,87.69 117.58,86.69 117.58,85.34 116.94,84.71 116.94,83.44 118.08,82.3 DIMM1.177
M_MA_B9: length 60.5
  TOP w0.089: v3(129.97,130.63) 130.4,130.2 CPU1.AW27
  GND w0.089: v3(129.97,130.63) 129.97,130 130.63,129.34 130.63,128.32 130.05,127.74 130.05,127.56
  GND w0.178: 130.05,127.56 130.05,126.06 130.86,125.25 130.86,117.17 arc(131.09,116.94) 131.32,117.17 131.32,119.28 arc(131.55,119.51) 131.78,119.28 131.78,116.92 129.84,114.99 129.84,105.18 128.03,103.37 128.03,92.5 127.1,91.57 126.74,91.57 125.6,90.42 125.07,90.42 123.04,88.39 123.04,87.5 121.89,86.36 121.89,85.7 120.84,84.64 DIMM1.175
M_MA_B10: length 67.9
  TOP w0.102: v5(121.72,134.32) 122.16,134.77 CPU1.AP18
  GND w0.089: 121.51,127.46 121.51,129.21 122.3,130 122.3,133.73 v5(121.72,134.32)
  GND w0.178: DIMM1.70 105.84,88.47 108.31,90.93 109.27,90.93 110.08,91.74 110.08,92.79 111.1,93.8 111.1,94.73 112.07,95.7 112.07,96.82 111.1,97.79 111.1,98.73 113.23,100.86 113.23,107.78 117.37,111.92 arc(117.37,112.29) 117,112.29 113.03,108.32 arc(112.65,108.32) 112.65,108.69 121.51,117.55 121.51,127.46
M_MA_B11: length 63.7
  TOP w0.089: CPU1.AU27 130.39,132.03 v3(129.93,131.57)
  GND w0.089: 129.6,127.56 129.6,127.74 130.3,128.45 130.3,129.13 129.49,129.95 129.49,130.86 129.93,131.31 v3(129.93,131.57)
  GND w0.178: 129.6,127.56 129.6,125.87 130.43,125.04 130.43,116.22 129.39,115.18 129.39,105.44 126.58,102.62 126.58,97.38 arc(126.8,97.16) 127.03,97.38 127.03,102.36 arc(127.26,102.59) 127.49,102.36 127.49,96.82 127.58,96.73 127.58,94.71 126.09,93.22 126.09,91.56 125.46,90.93 124.56,90.93 122.58,88.95 122.58,87.69 120.98,86.1 DIMM1.55
M_MA_B12: length 63.1
  TOP w0.089: v3(130.84,130.66) 130.42,131.08 CPU1.AV27
  GND w0.089: 131.8,126.31 131.8,128.1 131.3,128.6 131.3,129.99 130.84,130.45 v3(130.84,130.66)
  GND w0.178: 131.8,126.31 131.8,124.09 arc(132.04,123.85) 132.28,124.09 132.28,125.36 arc(132.52,125.6) 132.77,125.36 132.77,116.62 130.76,114.61 130.76,104.8 128.96,103 128.96,100.95 arc(129.2,100.71) 129.44,100.95 129.44,102.53 arc(129.68,102.77) 129.92,102.53 129.92,97.79 131.05,96.66 131.05,93.87 126.59,89.41 125.35,89.41 124.58,88.64 124.58,87.14 123.9,86.46 123.9,85.71 122.39,84.2 DIMM1.174
M_MA_B13: length 64.8
  TOP w0.102: CPU1.AR15 v5(118.99,134.32)
  GND w0.089: v5(118.99,134.32) 119.15,133.99 119.28,133.74 119.4,133.51 119.4,132.02 118.57,131.19 118.57,129.44 117.98,128.85 117.98,127.46
  GND w0.178: DIMM1.196 99.58,84.46 99.58,86.69 100.58,87.69 100.58,89.57 102.65,91.64 103.17,91.64 103.61,92.08 103.61,93.11 104.62,94.13 104.62,95.12 103.61,96.14 103.61,96.9 104.58,97.88 104.58,99.42 105.69,100.53 105.69,101.3 arc(105.77,101.49) 105.95,101.57 106.39,101.57 arc(106.65,101.83) 106.39,102.09 105.95,102.09 arc(105.69,102.36) 105.95,102.62 106.39,102.62 arc(106.65,102.88) 106.39,103.15 105.95,103.15 arc(105.69,103.41) 105.95,103.68 106.39,103.68 arc(106.65,103.94) 106.39,104.2 105.95,104.2 arc(105.77,104.28) 105.69,104.47 105.69,106.63 117.98,118.92 117.98,127.46
M_MA_B14: length 60
  TOP w0.089: CPU1.AY28 131.33,129.25 131.9,128.68 v3(131.9,128.68)
  GND w0.089: v3(131.9,128.68) 131.9,128.68 132.16,128.42 132.16,127.51 133.22,126.44 133.22,126.06
  GND w0.178: 133.22,126.06 133.22,116.43 132.18,115.39 132.18,108.72 arc(131.94,108.48) 131.7,108.72 131.7,111.57 arc(131.46,111.81) 131.22,111.57 131.22,104.6 130.38,103.76 130.38,98.26 131.58,97.04 131.58,95.69 132.58,94.69 132.58,93.99 130.92,92.34 130.54,92.34 127.1,88.9 125.58,88.9 125.07,88.39 125.07,87.12 125.58,86.61 125.58,85.72 124.05,84.2 DIMM1.172
M_MA_B15: length 62.6
  TOP w0.089: v3(130.85,131.57) 131.31,132.03 CPU1.AU28
  GND w0.089: v3(130.85,131.57) 131.14,131.57 131.33,131.38 131.33,130.44 131.57,130.2 131.9,130.2 132.92,129.18 132.92,128.02 134.32,126.62 134.32,126.24
  GND w0.178: 134.32,126.24 134.32,116.07 133.22,114.98 133.22,107.43 arc(133.15,107.24) 132.96,107.16 132.85,107.16 arc(132.59,106.9) 132.85,106.64 132.96,106.64 arc(133.22,106.37) 132.96,106.11 132.85,106.11 arc(132.59,105.85) 132.85,105.58 132.96,105.58 arc(133.22,105.32) 132.96,105.06 132.85,105.06 arc(132.59,104.79) 132.85,104.53 132.96,104.53 arc(133.22,104.26) 132.96,104 132.85,104 arc(132.59,103.74) 132.85,103.47 132.96,103.47 arc(133.22,103.21) 132.96,102.95 132.85,102.95 arc(132.59,102.68) 132.85,102.42 132.96,102.42 arc(133.22,102.16) 132.96,101.89 132.85,101.89 arc(132.59,101.63) 132.85,101.37 132.97,101.37 arc(133.27,101.24) 133.37,100.94 133.37,99.95 134.63,98.7 134.63,97.69 133.83,96.9 133.83,95.63 134.58,94.89 134.58,94.08 133.58,93.08 133.58,91.95 127.99,86.36 127.99,85.09 125.2,82.3 DIMM1.171
M_ODT_A0: length 44.4
  TOP w0.089: CPU1.AW11 115.39,129.81 115.39,128.63 115.29,128.52 115.29,127.79
  TOP w0.165: DIMM2.195 100.84,94.68 101.7,95.54 101.7,96.93 101.12,97.51 101.12,98.73 115.29,112.91 115.29,127.79
M_ODT_A1: length 46.6
  TOP w0.089: CPU1.AU14 117.89,132.42 114.71,132.42 113.97,131.67 113.97,131.04
  TOP w0.165: DIMM2.77 98.84,98.74 113.97,113.87 113.97,131.04
M_ODT_B0: length 67.9
  TOP w0.089: v5(119.9,137.06) 120.22,137.06 120.36,136.92 CPU1.AM16
  GND w0.089: v5(119.9,137.06) 119.62,137.06 119.47,136.91 119.47,134.17 119.64,133.67 119.64,131.76 118.87,130.99 118.87,129.16 118.49,128.78 118.49,127.46
  GND w0.14: DIMM1.195 100.84,84.3 100.05,85.09 100.05,86.49 101.07,87.5 101.07,89.38 102.85,91.17 103.37,91.17 104.08,91.88 104.08,92.27 104.08,92.8 105.12,93.84 105.12,94.86 105.61,95.35 105.61,96.8 105.12,97.29 105.12,99.24 107.18,101.29 107.18,105.8 arc(106.93,106.05) 106.69,105.8 106.69,105.37 arc(106.44,105.13) 106.2,105.37 106.2,106.38 118.49,118.67 118.49,127.46
M_ODT_B1: length 68.6
  TOP w0.089: v5(119.9,137.97) CPU1.AL16
  GND w0.089: v5(119.9,137.97) 118.95,137.97 118.63,137.65 118.63,136.84 118.07,136.28 118.07,132.57 117.09,131.59 117.09,128.22 116.79,127.91 116.79,127.46
  GND w0.14: DIMM1.77 98.84,87.03 99.12,87.3 99.12,89.48 101.56,91.92 101.56,93.09 102.59,94.12 102.59,94.74 101.57,95.76 101.57,96.9 102.56,97.88 102.56,98.81 103.71,99.97 103.71,107.02 arc(103.96,107.26) 104.2,107.02 104.2,105.49 arc(104.45,105.25) 104.69,105.49 104.69,107.51 105.29,108.1 arc(105.39,108.15) 105.5,108.1 arc(105.61,108.06) 105.72,108.1 105.85,108.23 arc(105.89,108.34) 105.85,108.45 arc(105.8,108.56) 105.85,108.67 105.98,108.8 arc(106.09,108.84) 106.19,108.8 arc(106.3,108.75) 106.41,108.8 106.54,108.93 arc(106.58,109.03) 106.54,109.14 arc(106.49,109.25) 106.54,109.36 106.67,109.49 arc(106.78,109.53) 106.89,109.49 arc(106.99,109.44) 107.1,109.49 107.23,109.62 arc(107.28,109.73) 107.23,109.83 arc(107.19,109.94) 107.23,110.05 107.36,110.18 arc(107.47,110.23) 107.58,110.18 arc(107.69,110.14) 107.79,110.18 107.92,110.31 arc(107.97,110.42) 107.92,110.53 arc(107.88,110.63) 107.92,110.74 108.05,110.87 arc(108.16,110.92) 108.27,110.87 arc(108.38,110.83) 108.48,110.87 108.61,111 arc(108.66,111.11) 108.61,111.22 arc(108.57,111.33) 108.61,111.43 116.79,119.61 116.79,127.46
M_PARITY_A: length 1.4
  TOP w0.089: v3(119.94,129.77) 119.93,129.77 CPU1.AY15
  BOTTOM w0.089: v3(119.94,129.77) STP11.1
M_PARITY_B: length 2
  TOP w0.102: CPU1.AL20 v5(123.56,137.97)
  BOTTOM w0.089: v5(123.56,137.97) 123.56,138.01 STP39.1
M_PEX1_RX_N10: length 85.6
  TOP w0.102: M2_1.43 35.94,114.09 36.12,114.27 36.12,114.64 36.82,115.34 44.04,115.34 46.3,117.6 48.17,117.6 49.43,116.34 49.43,109.75 51.49,107.7 51.49,104.28 50.22,103.02 49.25,103.02 v1(49.12,102.9) ; v3(65.1,61.82) 65.03,61.9 PCH1.G29
  BOTTOM w0.089: 63.39,69.16 63.4,69.14 63.4,69.13 63.8,68.73 63.8,66.89 64.97,65.73 64.97,63.99 65.81,63.15 65.81,62.32 65.56,62.06 65.34,62.06 v3(65.1,61.82)
  BOTTOM w0.102: v1(49.12,102.9) 48.87,103.15 48.79,103.15 48.64,103 48.64,97.87 46.79,96.01 46.79,84.26 55.46,75.59 58.3,75.59 60.91,72.98 60.91,71.64 63.39,69.16
M_PEX1_RX_P10: length 85.5
  TOP w0.102: PCH1.E29 64.52,62.38 64.7,62.2 64.85,62.2 65.05,62.4 v3(65.05,62.48) ; v1(49.1,103.71) 49.1,103.63 49.5,103.23 50.14,103.23 51.28,104.37 51.28,107.61 49.23,109.67 49.23,116.26 48.08,117.4 46.38,117.4 44.12,115.14 36.91,115.14 36.32,114.55 36.32,114.18 36.44,114.07 M2_1.41
  BOTTOM w0.089: v3(65.05,62.48) 65.05,62.33 65.13,62.26 65.48,62.26 65.62,62.4 65.62,63.07 64.78,63.91 64.78,65.65 63.61,66.81 63.61,68.65 63.27,69 63.26,69 63.24,69.01
  BOTTOM w0.102: 63.24,69.01 60.71,71.55 60.71,72.9 58.22,75.39 55.37,75.39 46.58,84.18 46.58,96.1 48.44,97.95 48.44,103.08 48.71,103.35 48.95,103.35 49.1,103.5 v1(49.1,103.71)
M_PEX1_TX_N10: length 83.4
  TOP w0.089: 66.93,64.7 66.45,64.22 66.45,63.68 PCH1.C32
  TOP w0.102: C387.2 37.46,109.48 37.46,109.06 38.02,108.51 39.05,108.51 39.95,109.42 39.95,109.7 v2(40.28,110.03) 39.95,110.36 39.95,114.05 40.34,114.43 44.4,114.43 46.76,116.79 47.78,116.79 48.51,116.05 48.51,109.24 50.57,107.18 50.57,106.1 50.45,105.98 50.18,105.98 v1(49.91,106.25) ; v3(67.1,67.2) 66.93,67.03 66.93,64.7
  BOTTOM w0.089: 65.28,70.36 65.29,70.35 65.29,70.34 65.33,70.3 65.84,69.78 65.84,68.73 66.88,67.69 66.88,67.42 v3(67.1,67.2)
  BOTTOM w0.102: 65.28,70.36 64.54,71.09 64.54,72.75 60.33,76.96 56.11,76.96 50.85,82.22 50.85,105.6 50.55,105.89 50.27,105.89 v1(49.91,106.25)
M_PEX1_TX_P10: length 83.2
  TOP w0.089: PCH1.B32 66.21,64.26 66.6,64.64 66.6,64.65
  TOP w0.102: 66.6,64.65 66.73,64.78 66.73,66.94 v3(66.47,67.2) ; C388.2 37.8,109.76 37.67,109.63 37.67,109.14 38.1,108.71 38.96,108.71 39.75,109.5 39.75,111.28 v2(39.42,111.61) 39.75,111.94 39.75,114.13 40.25,114.63 44.31,114.63 46.68,116.99 47.86,116.99 48.72,116.14 48.72,109.32 50.77,107.26 50.77,106.01 50.54,105.78 50.23,105.78 v1(49.94,105.49)
  BOTTOM w0.089: v3(66.47,67.2) 66.69,67.42 66.69,67.61 65.65,68.65 65.65,69.71 65.2,70.16 65.15,70.2 65.14,70.2 65.13,70.21
  BOTTOM w0.102: 65.13,70.21 64.34,71.01 64.34,72.67 60.25,76.76 56.02,76.76 50.65,82.14 50.65,105.51 50.47,105.69 50.14,105.69 v1(49.94,105.49)
M_RAS_A_L: length 45.9
  TOP w0.089: 119.35,126.21 119.35,126.67 117.25,128.78 117.25,129.44 117.62,129.81 CPU1.AW13
  TOP w0.216: 119.35,126.21 119.35,122.64 arc(119.15,122.43) 118.94,122.64 118.94,123.46 arc(118.73,123.67) 118.52,123.46 118.52,113.69 104.58,99.76 104.58,97.78 103.84,97.03 DIMM2.192
M_RAS_B_L: length 68.4
  TOP w0.089: v5(121.73,137.06) 121.73,136.14 CPU1.AN18
  GND w0.089: v5(121.73,137.06) 121.56,136.89 121.56,135.08 120.88,134.4 120.88,128.12 120.53,127.77 120.53,127.46
  GND w0.178: 120.53,127.46 120.53,117.84 111.38,108.69 111.38,107.49 112.29,106.58 112.29,105.23 arc(112.06,105) 111.84,105.23 111.84,106.06 arc(111.61,106.29) 111.38,106.06 111.38,100.76 arc(111.15,100.53) 110.92,100.76 110.92,101.37 arc(110.69,101.6) 110.46,101.37 110.46,100.05 109.07,98.65 109.07,97.87 110.08,96.85 110.08,95.71 109.04,94.67 109.04,93.73 108.1,92.79 108.1,92.04 104.62,88.56 104.62,87.12 103.84,86.34 DIMM1.192
M_WE_A_L: length 47.8
  TOP w0.089: 118.97,125.96 118.97,126.49 117.04,128.42 117.04,129.8 117.2,129.96 117.2,130.38 117.48,130.66 118.07,130.66 CPU1.AV14
  TOP w0.216: 118.97,125.96 118.97,124.31 arc(118.76,124.1) 118.55,124.31 118.55,126.08 arc(118.34,126.29) 118.14,126.08 118.14,113.89 103.05,98.81 103.05,96.49 DIMM2.73
M_WE_B_L: length 69.8
  TOP w0.089: v5(120.82,137.97) CPU1.AL17
  GND w0.089: v5(120.82,137.97) 121.25,137.54 121.25,135.09 120.62,134.46 120.62,133.88 120.52,133.78 120.52,129.59 119.82,128.89 119.82,128 120.04,127.79 120.04,127.46
  GND w0.178: 120.04,127.46 120.04,117.98 110.82,108.76 110.82,104.44 arc(110.59,104.22) 110.36,104.44 110.36,107.77 arc(110.13,108) 109.91,107.77 109.91,103.12 109.68,102.9 109.68,100.09 108.61,99.02 108.61,97.66 109.63,96.65 109.63,96.01 108.58,94.96 108.58,93.95 107.65,93.01 107.65,92.23 105.4,89.98 104.21,89.98 103.45,89.23 103.45,88.67 103.1,88.32 103.1,86.36 DIMM1.73
MCLK: length 3.7
  TOP w0.102: R636.1 119.02,33.4 118.19,34.24 U38.41
MCUVDDH: length 2.1
  TOP w0.178: U7.38 187.24,230.94 187.2,230.98 v1(187.2,231.39)
  BOTTOM w0.254: v1(187.2,231.39) 187.2,231.72 187.25,231.78 SR2.1
MDAT: length 3.9
  TOP w0.102: R640.1 119.28,32.33 v2(118.41,33.2) 117.78,33.84 U38.40
MDI0_N: length 44.4
  TOP w0.102: U21.2 52.77,204.18 52.81,204.21 52.81,204.21 53.29,204.7 53.8,204.7 55.05,205.94 57.47,205.94 v1(57.68,206.15) ; USB2_LAN.P3 73.32,224.16 73.32,223.13 73.76,222.69 73.76,218.82 72.19,217.25 71.32,217.25 69.88,215.8 69.88,213.89 U18.6 69.88,213.71 69.88,212.86 70.41,212.33 70.41,210.19 69.01,208.79 69.01,208.68 C140.1 68.96,207.77 68.96,203.52 v1(69.24,203.24)
  BOTTOM w0.102: v1(57.68,206.15) 57.93,205.89 58.92,205.89 60.04,204.77 68.24,204.77 68.96,204.06 68.96,203.52 v1(69.24,203.24)
MDI0_P: length 44.4
  TOP w0.102: v1(68.33,203.24) 68.61,203.52 68.61,207.82 C139.1 68.66,208.73 68.66,208.94 70.05,210.34 70.05,211.21 U18.1 70.05,211.38 70.05,212.18 69.52,212.71 69.52,215.95 71.17,217.6 72.04,217.6 73.41,218.97 73.41,222.54 72.81,223.14 72.03,223.14 71.81,222.91 71.81,222.34 USB2_LAN.P2 ; v1(57.68,205.23) 57.32,205.59 55.19,205.59 53.95,204.34 53.44,204.34 53.17,204.07 U21.1
  BOTTOM w0.102: v1(57.68,205.23) 57.98,205.54 58.78,205.54 59.89,204.42 68.1,204.42 68.61,203.91 68.61,203.52 v1(68.33,203.24)
MDI1_N: length 48.3
  TOP w0.102: U21.5 51.57,206.63 52.7,207.77 55.93,207.77 v1(56.21,208.05) ; v1(71.68,204.89) 71.4,205.17 71.4,207.79 C142.1 71.48,208.63 71.48,208.97 72.31,209.8 72.31,212.22 71.78,212.75 71.78,213.71 U18.4 71.78,213.88 71.78,215.06 76.28,219.56 76.28,223.11 75.87,223.52 75.87,224.17 USB2_LAN.P5
  BOTTOM w0.102: v1(56.21,208.05) 56.44,207.82 58.72,207.82 60.29,206.25 70.91,206.25 71.4,205.76 71.4,205.17 v1(71.68,204.89)
MDI1_P: length 48.2
  TOP w0.102: v1(70.76,204.89) 71.04,205.17 71.04,207.79 C141.1 71.12,208.78 71.12,209.11 71.96,209.95 71.96,211.21 U18.3 71.96,211.39 71.96,212.07 71.42,212.6 71.42,215.21 75.92,219.7 75.92,222.97 75.47,223.42 75.08,223.42 74.83,223.17 USB2_LAN.P4 ; v1(56.21,207.14) 55.93,207.42 52.85,207.42 51.92,206.49 51.92,203.5 U21.4
  BOTTOM w0.102: v1(56.21,207.14) 56.54,207.47 58.57,207.47 60.15,205.89 70.76,205.89 71.04,205.61 71.04,205.17 v1(70.76,204.89)
MDI2_N: length 53
  TOP w0.102: U21.7 50.77,204.44 49.99,205.22 49.99,206.18 v1(49.71,206.46) ; v1(74.07,205.58) 73.79,205.86 73.79,207.77 C144.1 73.81,208.71 73.81,208.95 74.27,209.4 74.27,211.28 U17.1 74.24,211.44 74.24,212.3 74.78,212.83 74.78,215.93 78.71,219.86 78.71,223.39 78.41,223.69 78.41,224.17 USB2_LAN.P7
  BOTTOM w0.102: v1(74.07,205.58) 73.79,205.86 73.79,206.93 73.15,207.57 60.7,207.57 59.05,209.22 54.03,209.22 52.3,207.49 50.35,207.49 49.98,207.13 49.98,206.73 v1(49.71,206.46)
MDI2_P: length 53
  TOP w0.102: USB2_LAN.P6 77.37,223.19 77.65,223.47 78.13,223.47 78.36,223.24 78.36,220.01 74.42,216.07 74.42,213.93 U17.6 74.42,213.76 74.42,212.98 73.89,212.45 73.89,209.52 73.46,209.09 73.46,208.64 73.07,208.25 C143.1 73.43,207.82 73.43,205.86 v1(73.15,205.58) ; v1(50.63,206.46) 50.35,206.18 50.35,205.37 51.12,204.59 51.12,204.11 51.17,204.06 U21.6
  BOTTOM w0.102: v1(50.63,206.46) 50.34,206.75 50.34,206.98 50.49,207.14 52.45,207.14 54.18,208.86 58.9,208.86 60.55,207.21 73,207.21 73.43,206.78 73.43,205.86 v1(73.15,205.58)
MDI3_N: length 62.2
  TOP w0.102: v1(76.48,205.68) 76.2,205.96 76.2,207.77 C146.1 76.15,208.78 76.15,211.26 U17.3 76.15,211.43 76.15,212.35 76.66,212.86 76.66,215.73 81.25,220.32 81.25,223.51 81.08,223.68 81.08,224.3 USB2_LAN.P9 ; v1(46.56,206.5) 46.84,206.22 46.84,204.17 48.47,202.53 U21.10
  BOTTOM w0.102: v1(46.56,206.5) 46.86,206.8 46.86,207.59 48.01,208.74 51.69,208.74 53.45,210.49 59.54,210.49 61.24,208.79 74.19,208.79 76.2,206.78 76.2,205.96 v1(76.48,205.68)
MDI3_P: length 62.2
  TOP w0.102: USB2_LAN.P8 79.6,222.17 79.6,223.19 80.04,223.62 80.63,223.62 80.89,223.36 80.89,220.47 76.3,215.87 76.3,213.91 U17.4 76.3,213.78 76.3,213 75.79,212.5 75.79,208.63 C145.1 75.84,207.82 75.84,205.96 v1(75.56,205.68) ; U21.9 48.58,202.93 47.19,204.32 47.19,206.22 v1(47.47,206.5)
  BOTTOM w0.102: v1(47.47,206.5) 47.22,206.75 47.22,207.44 48.16,208.38 51.84,208.38 53.59,210.13 59.39,210.13 61.09,208.43 74.04,208.43 75.84,206.63 75.84,205.96 v1(75.56,205.68)
MIC1_JD: length 63.1
  TOP w0.254: AUDIO.13 48.2,238.07 42.14,238.07 40.28,239.93 33.1,239.93 29.54,236.37 29.54,231.34 36.55,224.33 36.55,212.6 34.65,210.69 25.41,210.69 R138.2
MIC1_L: length 73.1
  TOP w0.254: v1(25.93,236.4) 23.06,236.4 22.44,237.02 Q5.C1 ; R101.2 29.28,218.49 v1(31.14,218.49) ; R34.2 18.72,226.71 18.72,229.92 20.68,231.88 v1(26.75,231.88) ; R38.1 40.54,226.06 L1.1 v1(41.69,227.06)
  BOTTOM w0.254: v1(31.14,218.49) 30.99,218.49 30.25,219.23 30.25,221.41 31.88,223.04 31.88,226.75 v1(26.75,231.88) 25.93,232.69 v2(25.93,235.13) v1(25.93,236.4) 25.93,237.92 27.86,239.85 38.72,239.85 42.77,235.8 42.77,229.26 41.69,228.18 v1(41.69,227.06)
MIC1_L1: length 2.8
  TOP w0.254: C69.2 24.59,218.8 CODEC.21
MIC1_L2: length 1.7
  TOP w0.254: C69.1 27.71,218.26 R101.1
MIC1_L_P: length 1.4
  TOP w0.254: Q5.B1 23.09,234.92 R10.2
MIC1_LL: length 18.7
  TOP w0.254: AUDIO.14 47.09,234.82 43.61,231.34 43.61,228.08 44.07,227.62 44.07,223.75 43.77,223.45 D3.2 42.81,224.47 C32.1 43.12,226.03 L1.2
MIC1_R: length 77.3
  TOP w0.254: L2.1 37.98,223.15 R43.1 v1(37.98,225.43) ; Q5.C2 26.38,235.6 v1(26.7,235.92) ; R33.2 13.72,226.28 12.93,227.08 12.93,228.22 13.31,228.6 16.64,228.6 20.45,232.41 26.31,232.41 v1(26.77,232.87) ; v1(31.19,219.3) 29.1,219.3 R88.2
  BOTTOM w0.254: v1(31.19,219.3) 30.76,219.74 30.76,221.07 32.41,222.72 32.41,227.23 v1(26.77,232.87) 26.7,232.94 v1(26.7,235.92) v2(26.7,237.11) 26.7,237.9 28.14,239.34 38.51,239.34 42.27,235.59 42.27,229.71 v1(37.98,225.43)
MIC1_R1: length 3.7
  TOP w0.254: C54.2 24.99,220.73 23.57,219.3 CODEC.22
MIC1_R2: length 2.4
  TOP w0.254: C54.1 26.77,220.8 28.1,219.48 R88.1
MIC1_R_P: length 1.4
  TOP w0.254: Q5.B2 23.09,238.28 R5.2
MIC1_RR: length 31.2
  TOP w0.254: AUDIO.11 55.18,234.77 47.8,234.77 44.15,231.11 44.15,228.32 44.63,227.84 44.63,222.58 43.6,221.55 D3.1 39.25,221.55 C48.1 38.11,221.52 L2.2
MIC1_VREFO-L: length 3.6
  TOP w0.254: R34.1 19.15,223.88 19.39,223.65 CODEC.28
MIC1_VREFO-R: length 5.6
  TOP w0.254: R33.1 14.52,225.33 15.7,224.16 16.26,224.16 17.39,223.03 CODEC.32
MIC2-VREFO: length 8
  TOP w0.254: D1.3 14.6,226.81 14.6,225.98 15.93,224.66 16.48,224.66 18.39,222.76 CODEC.30
MIC2-VREFO_L: length 1.4
  TOP w0.254: D1.2 13.18,229.91 R19.1
MIC2-VREFO_R: length 1.4
  TOP w0.254: R21.1 14.45,229.91 D1.1
MIC2_JD: length 48
  TOP w0.254: F_AUDIO.6 7.09,201.55 8.15,200.48 8.15,199.52 7.52,198.88 6.58,198.88 5.94,199.52 5.94,200.23 4.75,201.42 3.99,201.42 2.21,203.2 2.21,225.3 3.94,227.03 11.93,227.03 R32.1
MIC2_L: length 80.4
  TOP w0.254: v1(14.83,233.17) 14.76,233.25 13.54,233.25 13.18,232.89 R19.2 ; F_AUDIO.1 5.69,211.33 7.52,211.33 8.2,210.64 8.2,208.86 8.92,208.15 C138.2 9.54,208.41 D11.2 9.93,209.5 11.36,208.07 R171.1 11.96,208.53 11.05,209.45 v1(10.82,209.45) ; R119.2 29.67,215.14 v1(29.95,215.42) ; v1(11.23,236.8) 11.14,236.9 Q1.C1
  BOTTOM w0.254: v1(10.82,209.45) 11.18,209.8 11.18,210.97 10.21,211.94 10.21,216.33 12.19,218.31 22.33,218.31 25.22,215.42 v1(29.95,215.42) 29.95,216.74 25.84,220.84 25.84,225.67 19.56,231.95 16.05,231.95 v1(14.83,233.17) 14.53,233.48 14.53,235.69 13.54,236.68 11.35,236.68 v1(11.23,236.8)
MIC2_L1: length 3.1
  TOP w0.102: 22.45,216.3 CODEC.16
  TOP w0.254: 22.45,216.3 23.83,216.3 C96.1
MIC2_L2: length 1.3
  TOP w0.254: C96.2 R119.1
MIC2_L_P: length 1.4
  TOP w0.254: Q1.B1 11.79,234.92 R6.2
MIC2_R: length 73.2
  TOP w0.254: F_AUDIO.3 3.35,208.84 3.35,211.58 4.5,212.72 R136.1 7.02,213.51 8.36,213.51 C124.2 9.54,212.34 D11.1 9.65,211.29 v1(9.65,210.44) ; R108.2 29.05,216.57 v1(29.26,216.36) ; v1(13.92,232.56) 14.45,232.03 R21.2 ; Q1.C2 12.79,235.6 v1(13.13,235.94)
  BOTTOM w0.254: v1(9.65,210.44) 9.65,216.53 12.19,219.07 22.33,219.07 25.04,216.36 v1(29.26,216.36) 29.26,216.51 25.32,220.45 25.32,225.45 19.46,231.32 15.16,231.32 v1(13.92,232.56) 13.92,235.15 v1(13.13,235.94)
MIC2_R1: length 2.8
  TOP w0.102: 22.45,216.8 CODEC.17
  TOP w0.254: C84.1 24.62,216.8 22.45,216.8
MIC2_R2: length 1.3
  TOP w0.254: R108.1 C84.2
MIC2_R_P: length 1.4
  TOP w0.254: Q1.B2 11.79,238.28 R1.2
MIN_LOAD_Q: length 74.6
  TOP w0.102: QN40.3 189.84,53.31 R414.1 v1(189.81,58.71) ; QN39.1 196.58,118.35 197.94,116.99 v1(197.94,116.05)
  BOTTOM w0.102: v1(197.94,116.05) 197.99,116 197.99,92.15 187.07,81.23 187.07,75.92 190.88,72.11 190.88,65.67 189.51,64.29 189.51,59 v1(189.81,58.71)
MPEX1_TX_N10: length 2.9
  TOP w0.102: C387.1 37.41,110.71 37.62,110.92 37.62,112.12 37.44,112.3 M2_1.37
MPEX1_TX_P10: length 2.9
  TOP w0.102: C388.1 37.98,110.71 37.82,110.87 37.82,112.17 37.94,112.28 M2_1.35
OPC_ZVM_L: length 1.5
  TOP w0.089: v3(140.92,145.26) 140.49,144.83 CPU1.AC38
  BOTTOM w0.089: STP38.1 141.4,145.75 v3(140.92,145.26)
P95_BST: length 2.5
  TOP w0.254: U35.10 123.67,52.46 123.67,51.38
  TOP w0.635: 123.67,51.38 123.16,50.88 R514.1
P95_BST_R: length 1.7
  TOP w0.635: C534.1 121.07,49.85 R514.2
P95_CS: length 2.5
  TOP w0.203: R513.2 127.15,51.07 127.15,52.78 126.97,52.97 U35.2
P95_FB: length 5.4
  TOP w0.254: U35.4 127.65,53.97 R492.1 128.02,53.56 v2(129.08,52.5) R500.2 R493.1
P95_FB_R: length 4.3
  TOP w0.102: C525.1 v2(132.18,55.68)
  TOP w0.254: R493.2 C523.2 132.15,54.74 C525.1 R485.2
P95_FB_RC: length 2.6
  TOP w0.102: C523.1 v2(130.11,55.7)
  TOP w0.254: C523.1 128.97,53.61 R492.2
P95_LG: length 11.1
  TOP w0.254: U35.6 v1(123.67,55.22)
  TOP w0.635: R542.1 v1(119.74,48.56)
  BOTTOM w0.635: v1(123.67,55.22) 123.67,51.91 v2(121.03,49.28) 120.32,48.56 v1(119.74,48.56)
P95_LG_R: length 1.9
  TOP w0.635: R542.2 QBL1.G
P95_PH: length 4
  TOP w0.254: v1(122.4,53.34) 122.53,53.47 U35.8
  BOTTOM w0.635: v1(122.4,53.34) v1(119.68,53.34)
  vias: v1(107.67,56.39) v1(108.05,51.18) v1(109.47,53.67) v1(109.96,56.52) v1(110.03,49.89) v1(112.37,50.42) v1(113.13,56.64) v1(113.13,54.48) v1(113.13,52.45) v1(118.97,54.23) v1(118.97,52.45)
P95_RF: length 2.6
  TOP w0.102: v2(128.02,55.7) R476.1
  TOP w0.254: U35.5 127.75,54.47 R476.1
P95_UG: length 5
  TOP w0.254: U35.9 123.2,52.97 122.4,52.17 122.4,52.1
  TOP w0.635: R474.1 121.13,52.68 121.72,52.1 v2(121.74,52.1) 122.4,52.1
P95_UG_R: length 3.5
  TOP w0.635: QBH1.G 119.13,56.32 R473.1 120.72,55.85 121.13,56.26
P95_VDD: length 21.6
  TOP w0.203: U35.3 127.1,53.47 127.66,52.91
  TOP w0.254: U35.7 123.12,53.97 122.68,54.41 v1(122.68,55.96)
  TOP w0.508: v1(127.86,52.27) 127.86,52.71 127.66,52.91 ; R512.1 v1(124.87,49.2)
  TOP w0.635: R457.1 124.37,56.96 C517.1 122.68,56.86 v1(122.68,55.96)
  BOTTOM w0.508: v1(124.87,49.2) 124.87,49.73 125.37,50.24 v2(126.11,50.24) 127,50.24 127.86,51.1 v1(127.86,52.27) 127.86,53.26 124.49,56.64 123.37,56.64 v1(122.68,55.96)
PC_BEEP: length 5.9
  TOP w0.102: CODEC.12 20.96,212.69 21.29,212.37 22.17,212.37 22.89,211.66 22.89,209.73 23.22,209.4 TP5.1
PCH_GPP_F22: length 339.7
  TOP w0.089: v3(69.39,55.95) PCH1.W39
  TOP w0.102: v1(69.19,22.02) 69.49,21.72 69.49,19.76 71.68,17.58 74.68,17.58 75.23,17.02 75.23,15.06 74.32,14.15 74.32,13.18 73.28,12.14 73.28,6.35 v1(73.61,6.02) ; U23.2 28.93,183.46 28.73,183.26 v1(28.73,182.12) ; v1(86.99,44.83) 87.15,44.98 89.64,44.98 90.12,45.47 90.12,53.34 89.41,54.05 87.81,54.05 R480.1 85.66,56.21 83.85,56.21 82.35,57.71 v3(80.82,57.71)
  BOTTOM w0.089: v3(69.39,55.95) 69.81,56.38 70.46,56.38 70.83,56.01 75.21,56.01 76.17,56.97 79.45,56.97 79.48,57
  BOTTOM w0.102: 79.48,57 80.11,57 v3(80.82,57.71) ; v1(86.99,44.83) 86.99,43.1 84.89,41 84.89,39.5 83.16,37.78 83.16,28.47 79.17,24.49 70.59,24.49 69.6,23.49 69.6,22.43 v1(69.19,22.02) ; v1(73.61,6.02) 73.56,5.97 56.34,5.97 55.5,6.81 50.24,6.81 48.34,8.71 48.34,10.87 43.87,15.34 40.41,15.34 39.22,16.54 33.35,16.54 30.51,13.69 24.95,13.69 23.74,14.91 19.2,14.91 15.85,18.26 15.85,19.35 12.09,23.11 12.09,26.97 11.23,27.84 11.23,52.07 9.12,54.18 9.12,59.59 7.57,61.14 7.57,64.83 9.42,66.69 9.42,101.83 22.07,114.48 22.07,124.31 26.31,128.55 26.31,139.17 25.65,139.83 25.65,182.6 25.93,182.88 v2(27.43,182.88) 28.19,182.12 v1(28.73,182.12)
PCH_INTRUDER_L: length 7.7
  TOP w0.089: 53.37,36.96 53.37,37.21 55.52,39.37 56.06,39.37 56.24,39.55 56.24,41.02 55.91,41.34 55.91,42.79 PCH1.BE11
  TOP w0.102: 53.37,36.96 R605.2
PCH_JTAG_TCK: length 12.8
  TOP w0.089: PCH1.AN3 51.43,48.69 51.11,48.38 50.56,48.38 50.27,48.67 45.69,48.67 45.59,48.77 45.06,48.77
  TOP w0.102: R532.1 40.15,47.73 40.74,47.73 41,47.98 43.66,47.98 44.45,48.77 45.06,48.77
PCH_JTAG_TDI: length 234
  TOP w0.089: PCH1.AP2 51.12,48.13 50.9,47.9 50.47,47.9 50.11,48.26 45.36,48.26 45.31,48.31 45.06,48.31
  TOP w0.102: 45.06,48.31 44.7,48.31 43.89,47.5 41.2,47.5 40.77,47.07 R541.2 39.29,46.61 37.56,46.61 36.66,47.5 36.66,48.06 36.06,48.67 35.08,48.67 33.27,46.86 33.27,44.3 32.38,43.41 32.38,38.91 32.72,38.58 32.72,37.59 31.98,36.86 31.98,32.59 31.48,32.09 29.38,32.09 28.14,30.86 27.03,30.86 25.81,29.64 23.19,29.64 v1(22.48,28.93) ; v1(26.52,117.04) 26.52,117.37 26.06,117.83 26.06,118.92 27.64,120.5 27.64,122.07 29.08,123.52 30.25,123.52 30.84,124.1 30.84,125.4 34.95,129.51 40,129.51 49.05,138.56 54.51,138.56 55.14,139.19 59.42,139.19 62.18,141.95 62.18,144.17 65.43,147.42 65.43,155.47 71.15,161.19 71.15,174.6 72.19,175.64 R271.2
  BOTTOM w0.102: v1(22.48,28.93) 22.45,28.93 21.46,29.92 21.46,31.03 21.41,31.08 21.41,31.09 20.47,32.03 20.47,46.69 16,51.16 16,67.42 15.21,68.2 15.21,77.57 13.69,79.1 13.69,80.26 v2(11.89,82.07) 11.4,82.55 11.4,101.56 26.52,116.68 v1(26.52,117.04)
PCH_JTAG_TDO: length 248.2
  TOP w0.089: PCH1.AP1 50.53,48.13 50.19,48.46 45.54,48.46 45.47,48.54 45.06,48.54
  TOP w0.102: v1(17.35,27.84) 18.41,27.84 18.82,27.43 21.13,27.43 21.87,28.17 21.87,29.08 22.71,29.92 25.76,29.92 26.95,31.12 27.91,31.12 31.37,34.57 31.37,43.84 32.23,44.7 32.23,48.26 33.76,49.78 36.47,49.78 R528.2 37.15,48.98 37.64,48.49 37.64,47.68 37.82,47.5 40.86,47.5 41.11,47.75 43.79,47.75 44.58,48.54 45.06,48.54 ; v1(13.54,47.32) 13.79,47.32 18.14,51.66 18.14,66.21 26.49,74.57 26.49,82.52 19.76,89.26 19.76,89.27 19.74,89.29 19.74,97.62 19.08,98.28 19.08,103.07 17.4,104.75 17.4,104.78 17.4,107.16 23.39,113.15 23.39,113.15 23.75,113.51 23.75,117.14 24.44,117.83 25.13,117.83 25.58,118.28 25.58,119.14 25.63,119.2 25.63,119.2 27.18,120.75 27.18,122.43 34.72,129.97 39.8,129.97 48.84,139.01 54.31,139.01 54.94,139.65 59.22,139.65 61.72,142.15 61.72,144.6 64.97,147.85 64.97,155.91 70.69,161.62 70.69,169.16 69.85,170 69.85,176.61 69.16,177.29 69.16,178.36 69.88,179.07 R263.2
  BOTTOM w0.102: v1(13.54,47.32) 13.77,47.32 16.03,45.06 16.03,28.7 16.89,27.84 v1(17.35,27.84)
PCH_JTAG_TMS: length 261.6
  TOP w0.089: PCH1.AR2 50.28,47.51 49.94,47.85 45.06,47.85
  TOP w0.102: v1(12.6,47.35) 13.06,47.8 13.77,47.8 17.91,51.94 17.91,66.31 26.26,74.67 26.26,82.4 19.46,89.2 19.46,97.58 18.85,98.19 18.85,102.97 17.14,104.67 17.14,107.23 23.52,113.6 23.52,117.23 24.35,118.06 24.94,118.06 25.07,118.19 25.07,118.19 25.35,118.47 25.35,119.25 26.95,120.85 26.95,122.53 34.62,130.2 39.7,130.2 48.74,139.24 54.2,139.24 54.84,139.88 59.13,139.88 61.49,142.25 61.49,144.7 64.74,147.95 64.74,156.22 70.31,161.78 70.31,169.01 69.47,169.84 69.47,176.43 68.86,177.04 68.86,178.58 R262.2 ; v1(20.09,20.68) 20.46,20.68 22.43,22.65 22.43,25.57 27.24,30.38 28.32,30.38 29.5,31.56 31.59,31.56 32.46,32.43 32.46,36.63 33.17,37.34 33.17,38.81 32.87,39.12 32.87,41.59 R566.2 32.89,42.58 32.89,43.23 33.73,44.07 33.73,46.61 35.33,48.21 35.86,48.21 36.19,47.88 36.19,46.69 36.75,46.13 40.49,46.13 41.38,47.02 44.09,47.02 44.93,47.85 45.06,47.85
  BOTTOM w0.102: v1(20.09,20.68) 20.09,21.16 v2(19.35,21.89) 19.28,21.97 19.28,25.27 17.98,26.57 17.98,28.07 17.65,28.4 16.66,28.4 16.26,28.8 16.26,45.29 13.74,47.8 13.06,47.8 v1(12.6,47.35)
PCH_JTAGX: length 259.3
  TOP w0.089: 45.06,48.08 45.08,48.06 50.03,48.06 50.37,47.71 50.98,47.71 51,47.73 51.33,47.73 51.56,47.51 PCH1.AR3
  TOP w0.102: 45.06,48.08 44.83,48.08 43.99,47.24 41.27,47.24 40.41,46.38 37.46,46.38 36.42,47.42 36.42,47.97 35.96,48.44 35.24,48.44 33.5,46.7 33.5,44.2 32.61,43.31 32.61,39.01 32.94,38.68 32.94,37.47 32.23,36.75 32.23,32.52 31.54,31.83 29.44,31.83 28.24,30.63 27.17,30.63 22.2,25.67 22.2,22.74 20.8,21.34 19.84,21.34 v1(19.3,20.8) ; R269.2 R268.2 71.44,175.77 70.92,175.24 70.92,161.32 65.2,155.6 65.2,147.73 61.95,144.48 61.95,142.06 59.32,139.42 55.04,139.42 54.41,138.79 48.95,138.79 39.9,129.74 34.85,129.74 30.58,125.48 30.58,124.21 30.18,123.8 29.03,123.8 27.41,122.17 27.41,120.65 25.81,119.05 25.81,118.19 25.22,117.6 24.54,117.6 23.98,117.04 23.98,113.38 17.63,107.03 17.63,104.88 19.31,103.2 19.31,98.4 19.97,97.74 19.97,89.39 26.72,82.63 26.72,74.47 18.36,66.12 18.36,50.98 14.2,46.81 12.85,46.81 v1(12.62,46.58)
  BOTTOM w0.102: v1(12.62,46.58) 12.88,46.58 13.11,46.81 13.92,46.81 15.8,44.93 15.8,28.6 16.71,27.69 16.71,25.43 v2(17.17,24.97) 17.17,24.18 18.72,22.63 18.72,21.39 v1(19.3,20.8)
