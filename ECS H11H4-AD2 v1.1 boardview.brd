# Allegro board ECS H11H4-AD2 v1.1 boardview.brd (continued)
## Footprints (pads in the part's own frame, mm; a bottom-side part is the same pattern mirrored in y, then rotated) (continued)
LQFP48
  round 1.016 smd: (-4.216,-3.977) (4.263,4.278)
  rect 1.524x0.432 smd: 1(-4.25,2.826) 12(-4.25,-2.826) 25(4.25,-2.826) 36(4.25,2.826)
  rect 1.524x0.279 smd: 2(-4.25,2.25) 3(-4.25,1.75) 4(-4.25,1.25) 5(-4.25,0.75) 6(-4.25,0.25) 7(-4.25,-0.25) 8(-4.25,-0.75) 9(-4.25,-1.25) 10(-4.25,-1.75) 11(-4.25,-2.25) 26(4.25,-2.25) 27(4.25,-1.75) 28(4.25,-1.25) 29(4.25,-0.75) 30(4.25,-0.25) 31(4.25,0.25) 32(4.25,0.75) 33(4.25,1.25) 34(4.25,1.75) 35(4.25,2.25)
  rect 0.432x1.524 smd: 13(-2.826,-4.25) 24(2.826,-4.25) 37(2.826,4.25) 48(-2.826,4.25)
  rect 0.279x1.524 smd: 14(-2.25,-4.25) 15(-1.75,-4.25) 16(-1.25,-4.25) 17(-0.75,-4.25) 18(-0.25,-4.25) 19(0.25,-4.25) 20(0.75,-4.25) 21(1.25,-4.25) 22(1.75,-4.25) 23(2.25,-4.25) 38(2.25,4.25) 39(1.75,4.25) 40(1.25,4.25) 41(0.75,4.25) 42(0.25,4.25) 43(-0.25,4.25) 44(-0.75,4.25) 45(-1.25,4.25) 46(-1.75,4.25) 47(-2.25,4.25)
PCIE_X1_36P_2
  round 2.362 hole 2.362 unplated: (0,0) (0,-9.144)
  rect 1.067x1.067 hole 0.711: A1(1.245,11.654)
  round 1.067 hole 0.711: A2(3.251,10.653) A3(1.245,9.652) A4(3.251,8.651) A5(1.245,7.653) A6(3.251,6.652) A7(1.245,5.652) A8(3.251,4.653) A9(1.245,3.653) A10(3.251,2.652) A11(1.245,1.654) A12(3.251,-1.349) A13(1.245,-2.347) A14(3.251,-3.348) A15(1.245,-4.348) A16(3.251,-5.347) A17(1.245,-6.347) A18(3.251,-7.346) B1(-1.245,11.654) B2(-3.251,10.653) B3(-1.245,9.652) B4(-3.251,8.651) B5(-1.245,7.653) B6(-3.251,6.652) B7(-1.245,5.652) B8(-3.251,4.653) B9(-1.245,3.653) B10(-3.251,2.652) B11(-1.245,1.654) B12(-3.251,-1.349) B13(-1.245,-2.347) B14(-3.251,-3.348) B15(-1.245,-4.348) B16(-3.251,-5.347) B17(-1.245,-6.347) B18(-3.251,-7.346)
PCIE_X16_164P_4
  round 2.362 hole 2.362 unplated: (0,0) (0,-73.15)
  rect 1.067x1.067 hole 0.711: A1(1.25,11.65)
  round 1.067 hole 0.711: A2(3.25,10.65) A3(1.25,9.65) A4(3.25,8.65) A5(1.25,7.65) A6(3.25,6.65) A7(1.25,5.65) A8(3.25,4.65) A9(1.25,3.65) A10(3.25,2.65) A11(1.25,1.65) A12(3.25,-1.35) A13(1.25,-2.35) A14(3.25,-3.35) A15(1.25,-4.35) A16(3.25,-5.35) A17(1.25,-6.35) A18(3.25,-7.35) A19(1.25,-8.35) A20(3.25,-9.35) A21(1.25,-10.35) A22(3.25,-11.35) A23(1.25,-12.35) A24(3.25,-13.35) A25(1.25,-14.35) A26(3.25,-15.35) A27(1.25,-16.35) A28(3.25,-17.35) A29(1.25,-18.35) A30(3.25,-19.35) A31(1.25,-20.35) A32(3.25,-21.35) A33(1.25,-22.35) A34(3.25,-23.35) A35(1.25,-24.35) A36(3.25,-25.35) A37(1.25,-26.35) A38(3.25,-27.35) A39(1.25,-28.35) A40(3.25,-29.35) A41(1.25,-30.35) A42(3.25,-31.35) A43(1.25,-32.35) A44(3.25,-33.35) A45(1.25,-34.35) A46(3.25,-35.35) A47(1.25,-36.35) A48(3.25,-37.35) A49(1.25,-38.35) A50(3.25,-39.35) A51(1.25,-40.35) A52(3.25,-41.35) A53(1.25,-42.35) A54(3.25,-43.35) A55(1.25,-44.35) A56(3.25,-45.35) A57(1.25,-46.35) A58(3.25,-47.35) A59(1.25,-48.35) A60(3.25,-49.35) A61(1.25,-50.35) A62(3.25,-51.35) A63(1.25,-52.35) A64(3.25,-53.35) A65(1.25,-54.35) A66(3.25,-55.35) A67(1.25,-56.35) A68(3.25,-57.35) A69(1.25,-58.35) A70(3.25,-59.35) A71(1.25,-60.35) A72(3.25,-61.35) A73(1.25,-62.35) A74(3.25,-63.35) A75(1.25,-64.35) A76(3.25,-65.35) A77(1.25,-66.35) A78(3.25,-67.35) A79(1.25,-68.35) A80(3.25,-69.35) A81(1.25,-70.35) A82(3.25,-71.35) B1(-1.25,11.65) B2(-3.25,10.65) B3(-1.25,9.65) B4(-3.25,8.65) B5(-1.25,7.65) B6(-3.25,6.65) B7(-1.25,5.65) B8(-3.25,4.65) B9(-1.25,3.65) B10(-3.25,2.65) B11(-1.25,1.65) B12(-3.25,-1.35) B13(-1.25,-2.35) B14(-3.25,-3.35) B15(-1.25,-4.35) B16(-3.25,-5.35) B17(-1.25,-6.35) B18(-3.25,-7.35) B19(-1.25,-8.35) B20(-3.25,-9.35) B21(-1.25,-10.35) B22(-3.25,-11.35) B23(-1.25,-12.35) B24(-3.25,-13.35) B25(-1.25,-14.35) B26(-3.25,-15.35) B27(-1.25,-16.35) B28(-3.25,-17.35) B29(-1.25,-18.35) B30(-3.25,-19.35) B31(-1.25,-20.35) B32(-3.25,-21.35) B33(-1.25,-22.35) B34(-3.25,-23.35) B35(-1.25,-24.35) B36(-3.25,-25.35) B37(-1.25,-26.35) B38(-3.25,-27.35) B39(-1.25,-28.35) B40(-3.25,-29.35) B41(-1.25,-30.35) B42(-3.25,-31.35) B43(-1.25,-32.35) B44(-3.25,-33.35) B45(-1.25,-34.35) B46(-3.25,-35.35) B47(-1.25,-36.35) B48(-3.25,-37.35) B49(-1.25,-38.35) B50(-3.25,-39.35) B51(-1.25,-40.35) B52(-3.25,-41.35) B53(-1.25,-42.35) B54(-3.25,-43.35) B55(-1.25,-44.35) B56(-3.25,-45.35) B57(-1.25,-46.35) B58(-3.25,-47.35) B59(-1.25,-48.35) B60(-3.25,-49.35) B61(-1.25,-50.35) B62(-3.25,-51.35) B63(-1.25,-52.35) B64(-3.25,-53.35) B65(-1.25,-54.35) B66(-3.25,-55.35) B67(-1.25,-56.35) B68(-3.25,-57.35) B69(-1.25,-58.35) B70(-3.25,-59.35) B71(-1.25,-60.35) B72(-3.25,-61.35) B73(-1.25,-62.35) B74(-3.25,-63.35) B75(-1.25,-64.35) B76(-3.25,-65.35) B77(-1.25,-66.35) B78(-3.25,-67.35) B79(-1.25,-68.35) B80(-3.25,-69.35) B81(-1.25,-70.35) B82(-3.25,-71.35)
PSOP8_W150_PT50_PAD-UP6281_1
  rect 0.711x1.524 smd: 1(-1.905,-2.75) 2(-0.635,-2.75) 3(0.635,-2.75) 4(1.905,-2.75) 5(1.905,2.75) 6(0.635,2.75) 7(-0.635,2.75) 8(-1.905,2.75)
  rect 3x2.2 smd: 9(0,0)
PSOP8_W150_PT50_PAD-UP7719B_1
  rect 0.711x1.524 smd: 1(-1.905,-2.75) 2(-0.635,-2.75) 3(0.635,-2.75) 4(1.905,-2.75) 5(1.905,2.75) 6(0.635,2.75) 7(-0.635,2.75) 8(-1.905,2.75)
  rect 3.2x2.3 smd: 9(0,0)
Q_TDSON8-GDS-4
  rect 0.762x1.27 smd: D1(-1.905,2.857) D2(-0.635,2.857) D3(0.635,2.857) D4(1.905,2.857) G(1.905,-2.857) S1(-1.905,-2.857) S2(-0.635,-2.857) S3(0.635,-2.857)
  custom 0.902x0.902 smd: D5(0,1.054)
QFN16_PT05_2D1X2D6MM
  oval 0.762x0.279 smd: 1(-1.9,-0.75) 8(1.9,-0.75) 9(1.9,0.75) 16(-1.9,0.75)
  oval 0.279x0.762 smd: 2(-1.25,-1.65) 3(-0.75,-1.65) 4(-0.25,-1.65) 5(0.25,-1.65) 6(0.75,-1.65) 7(1.25,-1.65) 10(1.25,1.65) 11(0.75,1.65) 12(0.25,1.65) 13(-0.25,1.65) 14(-0.75,1.65) 15(-1.25,1.65)
  rect 2.6x2.1 smd: 17(0,0)
QFN32_PT04_NCP81102
  oval 0.66x0.203 smd: 1(-1.925,1.4) 2(-1.925,1) 3(-1.925,0.6) 4(-1.925,0.2) 5(-1.925,-0.2) 6(-1.925,-0.6) 7(-1.925,-1) 8(-1.925,-1.4) 17(1.925,-1.4) 18(1.925,-1) 19(1.925,-0.6) 20(1.925,-0.2) 21(1.925,0.2) 22(1.925,0.6) 23(1.925,1) 24(1.925,1.4)
  oval 0.203x0.66 smd: 9(-1.4,-1.925) 10(-1,-1.925) 11(-0.6,-1.925) 12(-0.2,-1.925) 13(0.2,-1.925) 14(0.6,-1.925) 15(1,-1.925) 16(1.4,-1.925) 25(1.4,1.925) 26(1,1.925) 27(0.6,1.925) 28(0.2,1.925) 29(-0.2,1.925) 30(-0.6,1.925) 31(-1,1.925) 32(-1.4,1.925)
  rect 2.7x2.7 smd: 33(0,0)
QFN32_PT04_UP1740Q_2
  round 0 smd: (-0.6,-2.1) (-0.2,-2.1) (0.046,-0.7) (0.2,-2.1) (0.6,-2.1) (1,-2.1) (1.4,-2.1) (2.1,1.4) (2.1,1) (2.1,0.6) (2.1,0.2) (2.1,-0.2) (2.1,-0.6) (2.1,-1) (2.1,-1.4)
  rect 0.8x0.2 smd: 1(-2.1,1.4) 2(-2.1,1) 3(-2.1,0.6) 4(-2.1,0.2) 5(-2.1,-0.2) 6(-2.1,-0.6) 7(-2.1,-1) 8(-2.1,-1.4)
  rect 0.2x0.8 smd: 9(-1.4,-2.1) 10(-1,-2.1) 14(1.4,2.1) 15(1,2.1) 16(0.6,2.1) 17(0.2,2.1) 18(-0.2,2.1) 19(-0.6,2.1) 20(-1,2.1) 21(-1.4,2.1)
  custom 0.2x0.2 smd: 11(0.4,-2.1) 13(2.1,0.8)
  custom 0.4x0.4 smd: 12(0.046,-0.7)
  rect 1.13x1.1 smd: 22(-0.88,0.9)
  rect 1.41x1.06 smd: 23(0.74,0.92)
QFN40_PT04_E2201
  oval 0.711x0.203 smd: 1(-2.4,1.8) 2(-2.4,1.4) 3(-2.4,1) 4(-2.4,0.6) 5(-2.4,0.2) 6(-2.4,-0.2) 7(-2.4,-0.6) 8(-2.4,-1) 9(-2.4,-1.4) 10(-2.4,-1.8) 21(2.4,-1.8) 22(2.4,-1.4) 23(2.4,-1) 24(2.4,-0.6) 25(2.4,-0.2) 26(2.4,0.2) 27(2.4,0.6) 28(2.4,1) 29(2.4,1.4) 30(2.4,1.8)
  oval 0.203x0.711 smd: 11(-1.8,-2.4) 12(-1.4,-2.4) 13(-1,-2.4) 14(-0.6,-2.4) 15(-0.2,-2.4) 16(0.2,-2.4) 17(0.6,-2.4) 18(1,-2.4) 19(1.4,-2.4) 20(1.8,-2.4) 31(1.8,2.4) 32(1.4,2.4) 33(1,2.4) 34(0.6,2.4) 35(0.2,2.4) 36(-0.2,2.4) 37(-0.6,2.4) 38(-1,2.4) 39(-1.4,2.4) 40(-1.8,2.4)
  rect 3.5x3.5 smd: 41(0,0)
QFN52_PT04_NCP61X1S_1
  round 1.016 smd: (-4.42,-4.089) (4.064,4.064)
  oval 0.66x0.203 smd: 1(-2.913,2.4) 2(-2.913,2) 3(-2.913,1.6) 4(-2.913,1.2) 5(-2.913,0.8) 6(-2.913,0.4) 7(-2.913,0) 8(-2.913,-0.4) 9(-2.913,-0.8) 10(-2.913,-1.2) 11(-2.913,-1.6) 12(-2.913,-2) 13(-2.913,-2.4) 27(2.913,-2.4) 28(2.913,-2) 29(2.913,-1.6) 30(2.913,-1.2) 31(2.913,-0.8) 32(2.913,-0.4) 33(2.913,0) 34(2.913,0.4) 35(2.913,0.8) 36(2.913,1.2) 37(2.913,1.6) 38(2.913,2) 39(2.913,2.4)
  oval 0.203x0.66 smd: 14(-2.4,-2.913) 15(-2,-2.913) 16(-1.6,-2.913) 17(-1.2,-2.913) 18(-0.8,-2.913) 19(-0.4,-2.913) 20(0,-2.913) 21(0.4,-2.913) 22(0.8,-2.913) 23(1.2,-2.913) 24(1.6,-2.913) 25(2,-2.913) 26(2.4,-2.913) 40(2.4,2.913) 41(2,2.913) 42(1.6,2.913) 43(1.2,2.913) 44(0.8,2.913) 45(0.4,2.913) 46(0,2.913) 47(-0.4,2.913) 48(-0.8,2.913) 49(-1.2,2.913) 50(-1.6,2.913) 51(-2,2.913) 52(-2.4,2.913)
  rect 4.699x4.699 smd: 53(0,0)
R0402-SHORT_2
  custom 0.127x0.127 smd: 1(-0.508,0) 2(0.508,0)
R0402_2
  oval 0.572x0.508 smd: 1(-0.476,0) 2(0.476,0)
R0603-SHORT_1-NMNP
  custom 0.191x0.191 smd: 1(-0.762,0) 2(0.762,0)
R0603-SHORT_2
  custom 0.191x0.191 smd: 1(-0.762,0) 2(0.762,0)
R0603_2
  oval 0.889x0.762 smd: 1(-0.699,0) 2(0.699,0)
R0805_2
  oval 1.016x1.397 smd: 1(-0.889,0) 2(0.889,0)
R1206
  rect 1.524x1.778 smd: 1(-1.524,0) 2(1.524,0)
R2512_1
  rect 2.032x3.302 smd: 1(-2.875,0) 2(2.875,0)
RJ3_0402
  rect 0.635x0.508 smd: 1(-1.016,0) 2(0,0) 3(1.016,0)
RJ3_0805
  rect 1.143x1.397 smd: 1(-2.286,0) 2(0,0) 3(2.286,0)
RJ45_USB_22P-ICOTHING_2
  round 1.27 hole 0.914: 11(7.2,12.005) 12(4.66,12.005) 13(-4.66,12.005) 14(-7.2,12.005) P1(5.715,6.635) P2(4.445,9.175) P3(3.175,6.635) P4(1.905,9.175) P5(0.635,6.635) P6(-0.635,9.175) P7(-1.905,6.635) P8(-3.175,9.175) P9(-4.445,6.635) P10(-5.715,9.175)
  round 2.692 hole 2.337: G1(6.57,-3.515) G2(-6.57,-3.515) G3(6.57,2.165) G4(-6.57,2.165) G5(9.35,-6.145) G6(-9.35,-6.145) G7(9.35,6.535) G8(-9.35,6.535)
  round 1.295 hole 0.94: U1(-3.5,-0.805) U2(-1,-0.805) U3(1,-0.805) U4(3.5,-0.805) U5(-3.5,1.815) U6(-1,1.815) U7(1,1.815) U8(3.5,1.815)
SATA3_7P-HI-TOP
  round 1.372 smd: (-1.725,-0.379) (2.085,-0.379)
  round 1.118 hole 0.762: 1(3.995,0.01) 2(2.935,1.51) 3(1.235,1.51) 4(0.18,0.01) 5(-0.875,1.51) 6(-2.565,1.51) 7(-3.63,0.01)
  round 2.134 hole 1.372: 8(6.45,0.01) 9(-6.38,1.01)
SHORT2-NMNP
  custom 0.159x0.159 smd: 1(-0.318,0) 2(0.318,0)
SOD_123_2
  rect 1.194x1.219 smd: N(1.762,0) P(-1.762,0)
SOD_523
  rect 0.6x0.8 smd: N(0.75,0) P(-0.75,0)
SON6_SOT891_PT035_74AUP1G08
  rect 0.165x0.457 smd: 1(-0.35,-0.305)
  rect 0.165x0.406 smd: 2(0,-0.325) 3(0.35,-0.325) 4(0.35,0.325) 5(0,0.325) 6(-0.35,0.325)
SOP8_W150_PT50
  rect 0.66x1.778 smd: 1(-1.905,-2.667) 2(-0.635,-2.667) 3(0.635,-2.667) 4(1.905,-2.667) 5(1.905,2.667) 6(0.635,2.667) 7(-0.635,2.667) 8(-1.905,2.667)
SOP8_W210_PT50_SPI_1
  rect 0.508x1.727 smd: 1(-1.905,-4) 2(-0.635,-4) 3(0.635,-4) 4(1.905,-4) 5(1.905,4) 6(0.635,4) 7(-0.635,4) 8(-1.905,4)
SOT23_2MM_2
  rect 0.864x0.864 smd: 1(-0.95,-1) 2(0.95,-1) 3(0,1)
SOT23_3L
  rect 0.914x1.422 smd: 1(-0.95,-1.05) 2(0.95,-1.05) 3(0,1.05)
SOT23_5P_1
  rect 0.686x1.346 smd: 1(-0.95,-1.24) 2(0,-1.24) 3(0.95,-1.24) 4(0.95,1.24) 5(-0.95,1.24)
SOT23_6P_2
  rect 0.508x1.27 smd: 1(-0.95,-1.25) 2(0,-1.25) 3(0.95,-1.25) 4(0.95,1.25) 5(0,1.25) 6(-0.95,1.25)
SOT23_8P_1
  rect 0.457x1.219 smd: 1(-0.975,-1.31) 2(-0.325,-1.31) 3(0.325,-1.31) 4(0.975,-1.31) 5(0.975,1.31) 6(0.325,1.31) 7(-0.325,1.31) 8(-0.975,1.31)
SOT23_BCE_2
  rect 1.016x1.016 smd: B(-1.016,-1.143) C(0,1.143) E(1.016,-1.143)
SOT23_GDS_2
  rect 1.016x1.016 smd: D(0,1.143) G(-1.016,-1.143) S(1.016,-1.143)
SOT353_5P
  rect 0.432x1.168 smd: 1(-0.65,-0.9) 2(0,-0.9) 3(0.65,-0.9) 4(0.65,0.9) 5(-0.65,0.9)
SOT363_6P
  rect 0.457x0.711 smd: B1(0,-1) B2(0,1) C1(-0.65,1) C2(0.65,-1) E1(-0.65,-1) E2(0.65,1)
SOT_563_6P_1
  rect 0.254x0.61 smd: 1(-0.5,-0.749) 2(0,-0.749) 3(0.5,-0.749) 4(0.5,0.749) 5(0,0.749) 6(-0.5,0.749)
TO251_BCE_PT90_1
  oval 1.575x1.194 hole 1.194x0.813: B(-2.286,0) C(0,0) E(2.286,0)
TP4X20NP-BOT
  oval 0.102x0.508 smd: 1(0,0)
TP30_SMD
  round 0.762 smd: 1(0,0)
TQFP64_PT04_F71808A
  round 1.016 smd: (-4.318,-4.318) (4.318,4.318)
  rect 1.524x0.356 smd: 1(-4.2,3.089) 16(-4.2,-3.089) 33(4.2,-3.089) 48(4.2,3.089)
  rect 1.524x0.178 smd: 2(-4.2,2.6) 3(-4.2,2.2) 4(-4.2,1.8) 5(-4.2,1.4) 6(-4.2,1) 7(-4.2,0.6) 8(-4.2,0.2) 9(-4.2,-0.2) 10(-4.2,-0.6) 11(-4.2,-1) 12(-4.2,-1.4) 13(-4.2,-1.8) 14(-4.2,-2.2) 15(-4.2,-2.6) 34(4.2,-2.6) 35(4.2,-2.2) 36(4.2,-1.8) 37(4.2,-1.4) 38(4.2,-1) 39(4.2,-0.6) 40(4.2,-0.2) 41(4.2,0.2) 42(4.2,0.6) 43(4.2,1) 44(4.2,1.4) 45(4.2,1.8) 46(4.2,2.2) 47(4.2,2.6)
  rect 0.356x1.524 smd: 17(-3.089,-4.2) 32(3.089,-4.2) 49(3.089,4.2) 64(-3.089,4.2)
  rect 0.178x1.524 smd: 18(-2.6,-4.2) 19(-2.2,-4.2) 20(-1.8,-4.2) 21(-1.4,-4.2) 22(-1,-4.2) 23(-0.6,-4.2) 24(-0.2,-4.2) 25(0.2,-4.2) 26(0.6,-4.2) 27(1,-4.2) 28(1.4,-4.2) 29(1.8,-4.2) 30(2.2,-4.2) 31(2.6,-4.2) 50(2.6,4.2) 51(2.2,4.2) 52(1.8,4.2) 53(1.4,4.2) 54(1,4.2) 55(0.6,4.2) 56(0.2,4.2) 57(-0.2,4.2) 58(-0.6,4.2) 59(-1,4.2) 60(-1.4,4.2) 61(-1.8,4.2) 62(-2.2,4.2) 63(-2.6,4.2)
unnamed#2
  custom 0.375x0.375 smd: (0,0)
unnamed#3
  round 3.15 hole 3.15 unplated: (-18.1,-12) (18.1,12)
USB3_18P4R-LOTES-SHORTBODY_1
  rect 1.067x1.067 hole 0.711: 1(-3.5,3.83)
  round 1.067 hole 0.711: 2(-1,3.83) 3(1,3.83) 4(3.5,3.83) 5(4,5.33) 6(2,5.33) 7(0,5.33) 8(-2,5.33) 9(-4,5.33) 10(-3.5,7.03) 11(-1,7.03) 12(1,7.03) 13(3.5,7.03) 14(4,8.53) 15(2,8.53) 16(0,8.53) 17(-2,8.53) 18(-4,8.53)
  round 2.692 hole 2.337: G1(-6.57,1.83) G2(6.57,1.83) G3(6.57,7.51) G4(-6.57,7.51)
WCM2012F2S_1
  rect 0.75x0.4 smd: 1(-0.925,0.425) 2(0.925,0.425) 3(0.925,-0.425) 4(-0.925,-0.425)

## Nets
3VR_GO: C609.2 QN29.1 R693.2 R704.1
3VSBSW_L: R439.1 R440.2 U38.37
5VDLA: C474.1 Q25.C QN20.3 R411.2
5VDLSB: C469.2 Q23.G Q26.C R415.2
12VR_GO: C602.2 QN27.1 R666.1 R667.2
+1V05_SA: C247.2 C248.2 CPU1.AA6 CPU1.AA7 CPU1.AB6 CPU1.AB7 CPU1.AB8 CPU1.AC7 CPU1.AC8 CPU1.N7 CPU1.P7 CPU1.R7 CPU1.T7 CPU1.U7 CPU1.V7 CPU1.W7 CPU1.Y6 CPU1.Y7 CPU1.Y8 EC13.1 EC16.1 L15.2 R215.1 SC20.2 SC21.1 SC25.2 SC26.2 SC28.1 SC29.2
+1V8_AVCC: C13.1 C14.1 C34.1 PFB4.2 U7.21 U7.27 U7.28
+1V8_IVDD: C4.1 C5.1 C41.1 C43.1 PFB1.2 U7.11 U7.20 U7.37 U7.39
+1V8_IVDDO: C2.1 PFB1.1 PFB3.1 PFB4.1 U7.32
+1V8_VDDC: C11.1 C15.1 C20.1 PFB3.2 U7.5 U7.6
+3V3_IVDD: C6.1 PFB2.2 U7.29 U7.30
+3V3_OVDD: C33.1 C45.1 PFB6.2 U7.10 U7.40
+3VSB: C226.1 C227.1 C231.1 C232.1 C321.1 C358.1 C497.1 C498.1 C499.1 C500.1 C501.1 C504.1 C514.1 C620.1 C623.2 D22.1 D22.2 EC32.1 ME_TEST.3 PCH1.AD41 PCH1.AJ41 PCH1.AL41 PCH1.AN5 PCH1.BA20 PCH1.BC42 PCH1.BD40 PCH1.BE41 PCH1.BE42 PCH1.BE43 PCIE1X.B10 PCIE16X.B10 Q6.E Q27.D QSW2.3 R89.1 R302.2 R308.1 R316.1 R322.1 R326.1 R348.1 R356.2 R361.2 R369.1 R370.1 R412.1 R421.1 R422.2 R429.1 R435.1 R440.1 R441.1 R442.1 R443.1 R444.2 R445.2 R449.2 R458.2 R461.2 R463.1 R464.1 R478.2 R479.1 R494.2 R496.1 R503.2 R504.2 R509.2 R510.1 R511.2 R521.1 R530.2 R531.1 R534.2 R535.2 R549.2 R565.2 R577.2 R579.2 R580.1 R588.2 R591.2 R595.1 R596.2 R599.1 R601.1 R610.2 R611.2 R614.2 R615.2 R622.2 R625.2 R626.2 R631.2 R634.2 R635.2 R642.2 R651.1 R654.2 R657.2 R669.2 R670.2 R674.1 R678.2 R680.2 R688.2 R691.2 R698.2 R703.1 R716.2 R719.2 R726.2 R729.2 R736.1 R740.2 R743.1 RJ1.1 RJ5.1 RJ6.1 RJ7.1 SC52.2 SR28.2 SR29.2 U26.4 U41.5
+5V_DUAL: C454.1 C492.2 EC27.1 PFB7.2 Q23.D QN20.1 QN20.2 QN20.5 QN20.6 QN20.7 R396.2 R398.1 R751.1 R754.1 R760.1 R762.1
+5V_DUAL_PFB: C470.2 C472.2 C483.2 C484.2 C488.2 PFB7.1 R399.2 U31.13 U31.23
+5V_HDMI: C18.1 C19.1 D4.3 HDMI1.18 PFB5.1 SC5.1 SC10.1 U8.5 U11.5
+5V_HDMI0: D2.3 F2.2 HDMI2.18
+5VA: C17.1 C26.1 C50.1 C64.1 CODEC.25 CODEC.38
+5VDUAL_1P0A: C505.1 C506.1 EC29.1 PFB8.1 PFB9.1 Q28.D Q29.D R457.2
+5VSB: C110.1 C469.1 C494.1 C528.1 C539.1 Q23.S Q29.S Q30.D R306.1 R415.1 R425.1 R489.1 R757.2 RJ4.1 SR765.1 SR768.1 U15.5 U20.2 U30.2 U33.5 U40.2
+12V: ATX_POWER.10 ATX_POWER.11 C30.1 C101.1 C185.1 C195.1 C202.1 C204.1 C379.2 C389.1 C596.1 C597.1 CPU_FAN.2 D16.N D18.N EC10.1 EC25.1 L20.1 PCIE1X.A2 PCIE1X.A3 PCIE1X.B1 PCIE1X.B2 PCIE1X.B3 PCIE16X.A2 PCIE16X.A3 PCIE16X.B1 PCIE16X.B2 PCIE16X.B3 Q22.E R50.2 R125.2 R318.1 R358.2 R411.1 R420.2 R447.1 R501.1 R525.1 R562.1 R666.2 R668.1 R741.1 U34.8
+12V_4P: ATX_12V.3 ATX_12V.4 C182.2 C183.2 L12.1 Z2.1 Z3.1
+P1V0_PCH_VCCDSW: PCH1.BA29 SC55.2
+V1P0A: C289.1 C299.1 C516.2 C518.2 C519.1 C520.1 EC34.1 L23.2 PCH1.AA23 PCH1.AA26 PCH1.AA28 PCH1.AC17 PCH1.AC23 PCH1.AC26 PCH1.AC28 PCH1.AD15 PCH1.AE23 PCH1.AE26 PCH1.AJ20 PCH1.AJ21 PCH1.AJ23 PCH1.AJ25 PCH1.N17 PCH1.R17 PCH1.R19 PCH1.U20 PCH1.U21 PCH1.U23 PCH1.U25 PCH1.U26 PCH1.V17 PCH1.V26 PCH1.V28 PCH1.Y23 PCH1.Y25 R289.1 R405.2 R446.2 R485.1 R528.1 R541.1 R556.2 R566.1 SC44.1 SC45.1 SC47.1 SC49.1 SC50.1 SC51.2 SR19.1 U26.1 U26.2
+V1P0A_VCCAMPHYPLL: C457.2 C458.2 PCH1.A43 PCH1.B43 PCH1.C44 PCH1.C45 R405.1
+V1P0A_VCCAPLL: C552.2 C553.2 PCH1.AJ5 PCH1.AL5 PCH1.AN19 R556.1
+V1P0A_VCCF24_1P0: C490.2 C491.2 PCH1.K2 PCH1.K3 R409.1 R446.1
+V1P0A_VCCST: C305.1 CPU1.V4 CPU1.V5 CPU1.V6 R142.2 R155.2 R158.2 R159.2 R265.1 R268.1 R276.1 R289.2 R487.1 SC53.1 SC54.1 SR6.1 SR7.1 SR8.1 SR9.1 U26.7 U26.8
+V3P3_WLAN: C382.1 C383.1 C384.1 C385.1 C386.1 M2_1.2 M2_1.4 M2_1.72 M2_1.74 QSW2.5 QSW2.6 QSW2.7 QSW2.8 SC39.1 SC40.1
+VBAT: BAT1.P R434.2
+VBAT_IO: C467.1 C610.1 CLR_CMOS.2 R416.1 U38.29
+VCC: ATX_POWER.4 ATX_POWER.6 ATX_POWER.21 ATX_POWER.22 ATX_POWER.23 BZ.P C93.1 C554.1 C558.1 C617.2 C621.1 C625.1 C626.1 C628.1 C634.1 C636.1 D21.N Q28.S Q44.E QN3.S QN10.S QN20.4 QN20.8 R42.1 R120.1 R391.2 R505.1 R564.1 R706.1 R720.1 R730.2 R731.2 R755.1 R764.1 U15.3 U20.1 U30.1 U33.3 U40.1
+VCC3: ATX_POWER.1 ATX_POWER.2 ATX_POWER.13 C121.1 C128.1 C157.1 C216.1 C217.1 C219.1 C225.1 C361.1 C363.2 C417.1 C418.1 C599.1 C616.2 C645.1 CODEC.1 D13.2 D24.2 EC11.1 LPC_DEBUG.9 M2_2.2 M2_2.4 M2_2.70 M2_2.72 M2_2.74 PCH1.AD13 PCIE1X.A9 PCIE1X.A10 PCIE1X.B8 PCIE16X.A9 PCIE16X.A10 PCIE16X.B8 PFB2.1 PFB6.1 PFB10.2 QN1.1 QN2.1 QN4.1 QN5.1 QN6.1 QN7.1 QN8.1 QN9.1 QSW2.1 R28.1 R35.1 R64.1 R65.1 R86.1 R103.1 R143.2 R144.2 R156.2 R176.2 R177.2 R199.2 R206.2 R225.2 R232.2 R253.2 R324.2 R345.1 R349.1 R357.1 R362.1 R366.2 R378.1 R379.2 R406.2 R407.2 R413.2 R418.2 R436.2 R451.2 R454.2 R455.2 R459.2 R480.2 R497.2 R526.1 R543.2 R545.2 R546.1 R550.2 R567.2 R573.2 R593.2 R600.2 R607.1 R608.1 R612.1 R613.2 R627.1 R629.1 R632.1 R638.2 R647.2 R652.1 R653.1 R655.1 R656.1 R658.2 R659.2 R660.2 R671.2 R675.1 R676.2 R677.1 R683.2 R684.2 R692.2 R695.2 R704.2 R727.2 R728.2 R734.2 R744.2 R745.2 R749.1 RJ1.3 SC48.1 SC60.1 SC61.1 SC63.1 SC69.1 SC70.1 SC71.1 SR34.1 U7.14 U23.5 U29.5
+VCCGT: C263.2 C264.2 C271.2 C272.2 C276.1 C280.1 C282.1 C295.1 C296.1 C304.1 C311.1 C315.1 C325.1 C331.1 CPU1.AA34 CPU1.AA35 CPU1.AA36 CPU1.AA37 CPU1.AA38 CPU1.AB33 CPU1.AB34 CPU1.G36 CPU1.G37 CPU1.G38 CPU1.G39 CPU1.G40 CPU1.H36 CPU1.H38 CPU1.H40 CPU1.J36 CPU1.J37 CPU1.J38 CPU1.J39 CPU1.J40 CPU1.K36 CPU1.K38 CPU1.K40 CPU1.L34 CPU1.L35 CPU1.L36 CPU1.L37 CPU1.L38 CPU1.L39 CPU1.L40 CPU1.M33 CPU1.M34 CPU1.M36 CPU1.M38 CPU1.M40 CPU1.N34 CPU1.N35 CPU1.N36 CPU1.N37 CPU1.N38 CPU1.N39 CPU1.N40 CPU1.P33 CPU1.P34 CPU1.P36 CPU1.P38 CPU1.P40 CPU1.R34 CPU1.R35 CPU1.R36 CPU1.R37 CPU1.R38 CPU1.R39 CPU1.R40 CPU1.T33 CPU1.T34 CPU1.T36 CPU1.T38 CPU1.T40 CPU1.U34 CPU1.U35 CPU1.U36 CPU1.U37 CPU1.U38 CPU1.U39 CPU1.U40 CPU1.V33 CPU1.V34 CPU1.V36 CPU1.V38 CPU1.V40 CPU1.W34 CPU1.W35 CPU1.W36 CPU1.W37 CPU1.W38 CPU1.Y33 CPU1.Y34 CPU1.Y36 CPU1.Y38 EC19.1 EC21.1 EC22.1 EC23.1 L17.2 L18.2 R214.2 SC23.1 SC24.1 SC27.1 SC31.1 SC32.1 SC33.1 SC34.1 SP7.1 SP9.1
+VCCIO: C290.1 C298.1 C306.1 C310.1 C319.1 C326.2 C336.2 C337.2 C338.2 C339.2 C340.2 C344.2 C352.2 CPU1.AJ23 CPU1.AK11 CPU1.AK14 CPU1.AK24 CPU1.M8 CPU1.P8 CPU1.T8 CPU1.U8 CPU1.W8 L19.2 R255.2 R285.2 R286.1 R327.1 SC36.1 U28.7
+VCCPFUSE_3P3: PCH1.BD3 PCH1.BE3 PCH1.BE4 R601.2
+VCCPGPPA: PCH1.BA31 R651.2
+VCCPGPPD: PCH1.BA45 PCH1.BB45 PCH1.BC44 PCH1.BC45 R599.2
+VCCPLL_OC_R: CPU1.AJ9 R299.1
+VCCPRIM_1P0: PCH1.AL22 SR19.2
+VDD_CLK: C548.2 C549.2 C556.2 C570.2 C576.2 C579.2 R592.1 R594.2 U37.2 U37.7 U37.9 U37.15 U37.16
+VIN_95V: C486.1 C487.1 C515.1 EC28.1 PFB8.2 PFB9.2 QBH1.D1 QBH1.D2 QBH1.D3 QBH1.D4 QBH1.D5
+VIN_CPU: C148.1 C150.2 C151.2 C152.2 C153.2 C222.2 C223.2 C224.2 C234.2 C244.2 C246.2 C261.2 C300.2 C341.2 C345.2 EC8.1 EC9.1 EC20.1 L10.1 L12.2 QCGH1.D1 QCGH1.D2 QCGH1.D3 QCGH1.D4 QCGH1.D5 QCGH2.D1 QCGH2.D2 QCGH2.D3 QCGH2.D4 QCGH2.D5 QCH1.D1 QCH1.D2 QCH1.D3 QCH1.D4 QCH1.D5 QCH2.D1 QCH2.D2 QCH2.D3 QCH2.D4 QCH2.D5 QCH3.D1 QCH3.D2 QCH3.D3 QCH3.D4 QCH3.D5 R181.2 R313.2 R320.2 R329.2 R414.2 Z1.1 Z2.2 Z3.2
+VIN_SA: C147.2 C169.2 C176.1 EC7.1 L10.2 QCSH1.D1 QCSH1.D2 QCSH1.D3 QCSH1.D4 QCSH1.D5
AV1N: R47.1 R48.1 R71.2 SP3.2
AV2N: R146.1 R147.2 R162.1 SP4.2
AV3N: R97.2 R98.1 R113.1 SP5.2
DGND: R124.1 USB2_LAN.P10
GND: A1.2 A2.2 ATX_12V.1 ATX_12V.2 ATX_POWER.3 ATX_POWER.5 ATX_POWER.7 ATX_POWER.15 ATX_POWER.17 ATX_POWER.18 ATX_POWER.19 ATX_POWER.24 BAT1.N BOSS1.1 BOSS2.1 BOSS3.1 C1.2 C2.2 C3.1 C4.2 C5.2 C6.2 C7.2 C8.2 C9.2 C10.2 C11.2 C12.2 C13.2 C14.2 C15.2 C16.2 C18.2 C19.2 C20.2 C21.2 C22.2 C28.2 C29.2 C30.2 C31.2 C33.2 C34.2 C35.2 C36.2 C37.1 C38.1 C41.2 C42.2 C43.2 C45.2 C46.2 C47.2 C51.2 C53.1 C55.1 C77.2 C85.1 C86.2 C87.2 C92.1 C93.2 C94.1 C95.2 C97.1 C100.2 C101.2 C105.2 C110.2 C117.1 C118.2 C119.2 C120.1 C121.2 C122.2 C123.1 C126.2 C127.2 C128.2 C129.2 C130.2 C131.2 C132.2 C133.1 C139.2 C140.2 C141.2 C142.2 C143.2 C144.2 C145.2 C146.2 C147.1 C148.2 C149.1 C150.1 C151.1 C152.1 C153.1 C155.1 C156.1 C157.2 C158.1 C169.1 C171.1 C172.2 C173.1 C176.2 C177.1 C179.2 C182.1 C183.1 C185.2 C186.2 C187.1 C188.1 C193.1 C195.2 C197.1 C201.1 C202.2 C203.2 C204.2 C207.2 C208.2 C209.1 C210.1 C212.1 C213.1 C214.2 C215.1 C216.2 C217.2 C218.1 C219.2 C220.1 C221.1 C222.1 C223.1 C224.1 C225.2 C226.2 C227.2 C229.2 C230.2 C231.2 C232.2 C233.2 C234.1 C239.1 C240.1 C244.1 C246.1 C247.1 C248.1 C249.1 C250.2 C251.2 C252.1 C253.1 C254.2 C256.2 C257.2 C261.1 C263.1 C264.1 C265.1 C267.2 C268.2 C271.1 C272.1 C273.2 C276.2 C277.2 C280.2 C281.2 C282.2 C283.2 C284.1 C285.1 C286.2 C287.2 C288.2 C289.2 C290.2 C292.2 C293.2 C294.2 C295.2 C296.2 C298.2 C299.2 C300.1 C303.2 C304.2 C305.2 C306.2 C309.2 C310.2 C311.2 C314.2 C315.2 C317.1 C318.2 C319.2 C320.1 C321.2 C322.2 C323.2 C324.2 C325.2 C326.1 C327.2 C329.2 C330.2 C331.2 C336.1 C337.1 C338.1 C339.1 C340.1 C341.1 C344.1 C345.1 C346.1 C349.2 C350.1 C355.1 C356.2 C358.2 C359.2 C360.2 C361.2 C363.1 C364.1 C367.1 C368.1 C370.1 C371.1 C379.1 C380.1 C381.1 C382.2 C383.2 C384.2 C385.2 C386.2 C389.2 C390.2 C391.2 C392.2 C393.2 C394.2 C395.2 C396.2 C397.2 C398.2 C399.2 C400.2 C401.2 C402.2 C403.2 C404.2 C405.2 C406.2 C407.2 C408.2 C409.2 C410.2 C411.2 C412.2 C413.2 C414.2 C415.2 C416.2 C417.2 C418.2 C420.2 C421.2 C422.2 C423.2 C424.2 C425.2 C427.2 C428.2 C429.2 C432.2 C433.2 C434.2 C435.2 C436.1 C437.1 C438.2 C439.2 C440.2 C441.1 C442.2 C443.1 C445.1 C446.1 C448.1 C449.1 C454.2 C457.1 C458.1 C464.1 C467.2 C468.2 C470.1 C471.1 C472.1 C474.2 C476.1 C478.1 C479.1 C480.2 C482.2 C483.1 C484.1 C486.2 C487.2 C488.1 C489.2 C490.1 C491.1 C492.1 C493.1 C494.2 C496.2 C497.2 C498.2 C499.2 C500.2 C501.2 C504.2 C505.2 C506.2 C509.2 C510.2 C511.2 C512.2 C513.2 C514.2 C515.2 C516.1 C517.2 C518.1 C519.2 C520.2 C521.2 C525.2 C526.2 C527.2 C529.1 C530.2 C531.2 C532.2 C533.1 C535.1 C536.1 C537.1 C538.1 C539.2 C540.2 C545.2 C546.2 C547.2 C548.1 C549.1 C550.2 C552.1 C553.1 C554.2 C555.2 C556.1 C557.2 C558.2 C559.1 C560.2 C562.2 C563.1 C568.2 C570.1 C571.2 C574.2 C576.1 C577.2 C579.1 C583.2 C584.2 C585.2 C586.2 C587.2 C588.2 C589.2 C590.2 C591.2 C592.2 C593.2 C594.2 C595.2 C596.2 C597.2 C598.2 C599.2 C600.2 C601.2 C602.1 C603.2 C604.2 C605.2 C606.2 C607.2 C608.2 C609.1 C610.2 C611.2 C612.2 C613.2 C615.2 C616.1 C617.1 C618.1 C619.1 C620.2 C621.2 C622.2 C623.1 C624.1 C625.2 C626.2 C627.2 C628.2 C629.2 C634.2 C635.2 C636.2 C637.2 C638.2 C639.2 C640.2 C641.2 C642.2 C643.2 C645.2 C646.1 CODEC.7 CPU1.A4 CPU1.A7 CPU1.A11 CPU1.A13 CPU1.A15 CPU1.A17 CPU1.A24 CPU1.AA3 CPU1.AA8 CPU1.AA33 CPU1.AB5 CPU1.AB39 CPU1.AC3 CPU1.AC6 CPU1.AC33 CPU1.AC34 CPU1.AC35 CPU1.AD1 CPU1.AD4 CPU1.AD6 CPU1.AD7 CPU1.AD8 CPU1.AD33 CPU1.AD36 CPU1.AD37 CPU1.AD38 CPU1.AD39 CPU1.AD40 CPU1.AE3 CPU1.AE5 CPU1.AE8 CPU1.AE33 CPU1.AE36 CPU1.AF1 CPU1.AF5 CPU1.AF8 CPU1.AF33 CPU1.AF36 CPU1.AF37 CPU1.AF40 CPU1.AG1 CPU1.AG2 CPU1.AG3 CPU1.AG4 CPU1.AG5 CPU1.AG8 CPU1.AG33 CPU1.AG36 CPU1.AH5 CPU1.AH8 CPU1.AH33 CPU1.AH36 CPU1.AH37 CPU1.AH38 CPU1.AH39 CPU1.AH40 CPU1.AJ1 CPU1.AJ4 CPU1.AJ5 CPU1.AJ8 CPU1.AJ31 CPU1.AJ32 CPU1.AJ33 CPU1.AJ34 CPU1.AJ35 CPU1.AJ36 CPU1.AK5 CPU1.AK6 CPU1.AK7 CPU1.AK8 CPU1.AK9 CPU1.AK10 CPU1.AK12 CPU1.AK13 CPU1.AK15 CPU1.AK16 CPU1.AK17 CPU1.AK18 CPU1.AK19 CPU1.AK20 CPU1.AK23 CPU1.AK25 CPU1.AK26 CPU1.AK28 CPU1.AK29 CPU1.AK30 CPU1.AK36 CPU1.AK37 CPU1.AK40 CPU1.AL1 CPU1.AL2 CPU1.AL3 CPU1.AL4 CPU1.AL5 CPU1.AL11 CPU1.AL14 CPU1.AL21 CPU1.AL24 CPU1.AL27 CPU1.AL30 CPU1.AL36 CPU1.AM5 CPU1.AM11 CPU1.AM14 CPU1.AM17 CPU1.AM19 CPU1.AM24 CPU1.AM27 CPU1.AM30 CPU1.AM31 CPU1.AM32 CPU1.AM33 CPU1.AM34 CPU1.AM35 CPU1.AM36 CPU1.AM37 CPU1.AM38 CPU1.AM39 CPU1.AM40 CPU1.AN1 CPU1.AN4 CPU1.AN5 CPU1.AN6 CPU1.AN7 CPU1.AN8 CPU1.AN9 CPU1.AN10 CPU1.AN11 CPU1.AN14 CPU1.AN16 CPU1.AN19 CPU1.AN22 CPU1.AN23 CPU1.AN24 CPU1.AN27 CPU1.AN30 CPU1.AN36 CPU1.AP5 CPU1.AP11 CPU1.AP14 CPU1.AP24 CPU1.AP27 CPU1.AP30 CPU1.AP36 CPU1.AP37 CPU1.AP40 CPU1.AR1 CPU1.AR2 CPU1.AR3 CPU1.AR4 CPU1.AR5 CPU1.AR11 CPU1.AR14 CPU1.AR16 CPU1.AR17 CPU1.AR18 CPU1.AR19 CPU1.AR20 CPU1.AR21 CPU1.AR22 CPU1.AR23 CPU1.AR24 CPU1.AR27 CPU1.AR30 CPU1.AR31 CPU1.AR32 CPU1.AR33 CPU1.AR34 CPU1.AR35 CPU1.AR36 CPU1.AT5 CPU1.AT6 CPU1.AT7 CPU1.AT8 CPU1.AT9 CPU1.AT10 CPU1.AT11 CPU1.AT12 CPU1.AT13 CPU1.AT14 CPU1.AT15 CPU1.AT17 CPU1.AT23 CPU1.AT24 CPU1.AT25 CPU1.AT26 CPU1.AT27 CPU1.AT28 CPU1.AT29 CPU1.AT30 CPU1.AT31 CPU1.AT32 CPU1.AT34 CPU1.AT36 CPU1.AT37 CPU1.AT38 CPU1.AT39 CPU1.AT40 CPU1.AU1 CPU1.AU4 CPU1.AU5 CPU1.AU7 CPU1.AU25 CPU1.AU30 CPU1.AU34 CPU1.AV2 CPU1.AV5 CPU1.AV9 CPU1.AV26 CPU1.AV28 CPU1.AV30 CPU1.AV34 CPU1.AV38 CPU1.AW3 CPU1.AW5 CPU1.AW9 CPU1.AW30 CPU1.AW32 CPU1.AW34 CPU1.AW36 CPU1.AY3 CPU1.AY5 CPU1.AY7 CPU1.AY9 CPU1.AY25 CPU1.AY27 CPU1.AY30 CPU1.B6 CPU1.B24 CPU1.B26 CPU1.B28 CPU1.B30 CPU1.B38 CPU1.C2 CPU1.C5 CPU1.C8 CPU1.C10 CPU1.C12 CPU1.C14 CPU1.C16 CPU1.C18 CPU1.C20 CPU1.C22 CPU1.C24 CPU1.C31 CPU1.C33 CPU1.C35 CPU1.C37 CPU1.D4 CPU1.D7 CPU1.D24 CPU1.D26 CPU1.D28 CPU1.D30 CPU1.D37 CPU1.D39 CPU1.D40 CPU1.E3 CPU1.E6 CPU1.E9 CPU1.E11 CPU1.E13 CPU1.E15 CPU1.E17 CPU1.E19 CPU1.E21 CPU1.E23 CPU1.E31 CPU1.E33 CPU1.E35 CPU1.E37 CPU1.F1 CPU1.F4 CPU1.F7 CPU1.F10 CPU1.F22 CPU1.F26 CPU1.F28 CPU1.F30 CPU1.F40 CPU1.G3 CPU1.G6 CPU1.G8 CPU1.G11 CPU1.G13 CPU1.G15 CPU1.G17 CPU1.G19 CPU1.G22 CPU1.G31 CPU1.G33 CPU1.H1 CPU1.H4 CPU1.H7 CPU1.H8 CPU1.H9 CPU1.H21 CPU1.H24 CPU1.H26 CPU1.H28 CPU1.H30 CPU1.H35 CPU1.H37 CPU1.H39 CPU1.J3 CPU1.J6 CPU1.J10 CPU1.J12 CPU1.J16 CPU1.J18 CPU1.J20 CPU1.J32 CPU1.J34 CPU1.K1 CPU1.K4 CPU1.K7 CPU1.K14 CPU1.K15 CPU1.K17 CPU1.K19 CPU1.K22 CPU1.K24 CPU1.K26 CPU1.K28 CPU1.K30 CPU1.K33 CPU1.K35 CPU1.K37 CPU1.K39 CPU1.L3 CPU1.L6 CPU1.L9 CPU1.L11 CPU1.L13 CPU1.L32 CPU1.M1 CPU1.M4 CPU1.M7 CPU1.M10 CPU1.M12 CPU1.M15 CPU1.M17 CPU1.M19 CPU1.M21 CPU1.M23 CPU1.M25 CPU1.M27 CPU1.M29 CPU1.M35 CPU1.M37 CPU1.M39 CPU1.N3 CPU1.N6 CPU1.N8 CPU1.N33 CPU1.P1 CPU1.P4 CPU1.P35 CPU1.P37 CPU1.P39 CPU1.R3 CPU1.R6 CPU1.R8 CPU1.R33 CPU1.T1 CPU1.T4 CPU1.T35 CPU1.T37 CPU1.T39 CPU1.U3 CPU1.U6 CPU1.U33 CPU1.V1 CPU1.V8 CPU1.V35 CPU1.V37 CPU1.V39 CPU1.W3 CPU1.W6 CPU1.W33 CPU1.Y5 CPU1.Y35 CPU1.Y37 CPU_FAN.1 D7.P D8.P D9.P D10.P D12.P D13.1 D19.8 D20.8 D23.1 D24.1 DIMM1.2 DIMM1.5 DIMM1.8 DIMM1.11 DIMM1.14 DIMM1.17 DIMM1.20 DIMM1.23 DIMM1.26 DIMM1.29 DIMM1.32 DIMM1.35 DIMM1.38 DIMM1.41 DIMM1.44 DIMM1.47 DIMM1.80 DIMM1.83 DIMM1.86 DIMM1.89 DIMM1.92 DIMM1.95 DIMM1.98 DIMM1.101 DIMM1.104 DIMM1.107 DIMM1.110 DIMM1.113 DIMM1.116 DIMM1.119 DIMM1.121 DIMM1.124 DIMM1.125 DIMM1.127 DIMM1.130 DIMM1.133 DIMM1.134 DIMM1.136 DIMM1.139 DIMM1.142 DIMM1.143 DIMM1.145 DIMM1.148 DIMM1.151 DIMM1.152 DIMM1.154 DIMM1.157 DIMM1.160 DIMM1.161 DIMM1.163 DIMM1.166 DIMM1.199 DIMM1.202 DIMM1.203 DIMM1.205 DIMM1.208 DIMM1.211 DIMM1.212 DIMM1.214 DIMM1.217 DIMM1.220 DIMM1.221 DIMM1.223 DIMM1.226 DIMM1.229 DIMM1.230 DIMM1.232 DIMM1.235 DIMM1.239 DIMM2.2 DIMM2.5 DIMM2.8 DIMM2.11 DIMM2.14 DIMM2.17 DIMM2.20 DIMM2.23 DIMM2.26 DIMM2.29 DIMM2.32 DIMM2.35 DIMM2.38 DIMM2.41 DIMM2.44 DIMM2.47 DIMM2.80 DIMM2.83 DIMM2.86 DIMM2.89 DIMM2.92 DIMM2.95 DIMM2.98 DIMM2.101 DIMM2.104 DIMM2.107 DIMM2.110 DIMM2.113 DIMM2.116 DIMM2.119 DIMM2.121 DIMM2.124 DIMM2.125 DIMM2.127 DIMM2.130 DIMM2.133 DIMM2.134 DIMM2.136 DIMM2.139 DIMM2.142 DIMM2.143 DIMM2.145 DIMM2.148 DIMM2.151 DIMM2.152 DIMM2.154 DIMM2.157 DIMM2.160 DIMM2.161 DIMM2.163 DIMM2.166 DIMM2.199 DIMM2.202 DIMM2.203 DIMM2.205 DIMM2.208 DIMM2.211 DIMM2.212 DIMM2.214 DIMM2.217 DIMM2.220 DIMM2.221 DIMM2.223 DIMM2.226 DIMM2.229 DIMM2.230 DIMM2.232 DIMM2.235 DIMM2.239 EC2.2 EC6.2 EC7.2 EC8.2 EC9.2 EC10.2 EC11.2 EC12.2 EC13.2 EC14.2 EC15.2 EC16.2 EC17.2 EC18.2 EC19.2 EC20.2 EC21.2 EC22.2 EC23.2 EC24.2 EC25.2 EC26.2 EC27.2 EC28.2 EC29.2 EC30.2 EC31.2 EC32.2 EC33.2 EC34.2 EC35.2 EC36.2 F_PANEL.5 F_PANEL.8 F_USB1.7 F_USB1.8 F_USB2.4 H2.1 H2.2 H2.3 H2.4 H2.5 H2.6 H2.7 H2.8 H3.1 H3.2 H3.3 H3.4 H3.5 H3.6 H3.7 H3.8 H4.1 H4.2 H4.3 H4.4 H4.5 H4.6 H4.7 H4.8 H5.1 H5.2 H5.3 H5.4 H5.5 H5.6 H5.7 H5.8 H6.1 H6.2 H6.3 H6.4 H6.5 H6.6 H6.7 H6.8 HDMI1.2 HDMI1.5 HDMI1.8 HDMI1.11 HDMI1.17 HDMI1.20 HDMI1.21 HDMI1.22 HDMI1.23 HDMI2.2 HDMI2.5 HDMI2.8 HDMI2.11 HDMI2.17 HDMI2.20 HDMI2.21 HDMI2.22 HDMI2.23 L24.1 LPC_DEBUG.2 LPC_DEBUG.12 LPC_DEBUG.17 M2_1.1 M2_1.7 M2_1.18 M2_1.33 M2_1.39 M2_1.45 M2_1.51 M2_1.57 M2_1.63 M2_1.69 M2_1.75 M2_1.76 M2_1.77 M2_2.1 M2_2.3 M2_2.21 M2_2.27 M2_2.33 M2_2.39 M2_2.45 M2_2.51 M2_2.57 M2_2.71 M2_2.73 M2_2.75 M2_2.76 M2_2.77 ME_TEST.6 PCH1.A2 PCH1.A3 PCH1.A4 PCH1.A18 PCH1.A25 PCH1.A32 PCH1.A37 PCH1.A42 PCH1.A44 PCH1.AA4 PCH1.AA17 PCH1.AA18 PCH1.AA20 PCH1.AA21 PCH1.AA25 PCH1.AA29 PCH1.AA42 PCH1.AB4 PCH1.AB5 PCH1.AB7 PCH1.AB8 PCH1.AB14 PCH1.AB15 PCH1.AB31 PCH1.AB32 PCH1.AB38 PCH1.AC1 PCH1.AC18 PCH1.AC20 PCH1.AC21 PCH1.AC25 PCH1.AC29 PCH1.AC45 PCH1.AD4 PCH1.AD8 PCH1.AD11 PCH1.AD14 PCH1.AD32 PCH1.AD33 PCH1.AD36 PCH1.AE4 PCH1.AE18 PCH1.AE20 PCH1.AE21 PCH1.AE25 PCH1.AE28 PCH1.AE29 PCH1.AE42 PCH1.AF18 PCH1.AF20 PCH1.AF21 PCH1.AF23 PCH1.AF25 PCH1.AF26 PCH1.AF28 PCH1.AF29 PCH1.AG4 PCH1.AG11 PCH1.AG13 PCH1.AG31 PCH1.AG32 PCH1.AG33 PCH1.AG38 PCH1.AH1 PCH1.AH17 PCH1.AH18 PCH1.AH20 PCH1.AH21 PCH1.AH23 PCH1.AH25 PCH1.AH26 PCH1.AH28 PCH1.AH29 PCH1.AH45 PCH1.AJ10 PCH1.AJ14 PCH1.AJ15 PCH1.AJ17 PCH1.AJ18 PCH1.AJ26 PCH1.AJ28 PCH1.AJ29 PCH1.AJ31 PCH1.AJ32 PCH1.AJ36 PCH1.AK4 PCH1.AK42 PCH1.AL4 PCH1.AL10 PCH1.AL11 PCH1.AL13 PCH1.AL17 PCH1.AL19 PCH1.AL24 PCH1.AL29 PCH1.AL32 PCH1.AL33 PCH1.AL38 PCH1.AM15 PCH1.AM17 PCH1.AM19 PCH1.AM22 PCH1.AM24 PCH1.AM27 PCH1.AM29 PCH1.AM45 PCH1.AN4 PCH1.AN7 PCH1.AN8 PCH1.AN10 PCH1.AN11 PCH1.AN22 PCH1.AN27 PCH1.AN31 PCH1.AN39 PCH1.AP4 PCH1.AP11 PCH1.AR5 PCH1.AR7 PCH1.AR9 PCH1.AR33 PCH1.AR34 PCH1.AR42 PCH1.AT9 PCH1.AT10 PCH1.AT15 PCH1.AT36 PCH1.AU1 PCH1.AU7 PCH1.AU35 PCH1.AU36 PCH1.AU39 PCH1.AU45 PCH1.AV6 PCH1.AV17 PCH1.AV24 PCH1.AV27 PCH1.AV31 PCH1.AV33 PCH1.AW9 PCH1.AW13 PCH1.AW19 PCH1.AW29 PCH1.AW37 PCH1.AY38 PCH1.AY45 PCH1.B1 PCH1.B2 PCH1.B3 PCH1.B6 PCH1.B25 PCH1.B37 PCH1.B40 PCH1.B44 PCH1.B45 PCH1.BA1 PCH1.BB1 PCH1.BB11 PCH1.BB16 PCH1.BB21 PCH1.BB25 PCH1.BB30 PCH1.BB34 PCH1.BC1 PCH1.BC2 PCH1.BD2 PCH1.BD43 PCH1.BD44 PCH1.BD45 PCH1.BE9 PCH1.BE14 PCH1.BE18 PCH1.BE23 PCH1.BE28 PCH1.BE32 PCH1.BE37 PCH1.BE40 PCH1.BE44 PCH1.C2 PCH1.C4 PCH1.C10 PCH1.C28 PCH1.C37 PCH1.C42 PCH1.D10 PCH1.D12 PCH1.D15 PCH1.D16 PCH1.D17 PCH1.D19 PCH1.D21 PCH1.D24 PCH1.D25 PCH1.D27 PCH1.D29 PCH1.D30 PCH1.D31 PCH1.D33 PCH1.D35 PCH1.D36 PCH1.D45 PCH1.E13 PCH1.E15 PCH1.E31 PCH1.E33 PCH1.F8 PCH1.F44 PCH1.G9 PCH1.G42 PCH1.H3 PCH1.H17 PCH1.H19 PCH1.H22 PCH1.H24 PCH1.H27 PCH1.H29 PCH1.H35 PCH1.J3 PCH1.J5 PCH1.J7 PCH1.J10 PCH1.J11 PCH1.J39 PCH1.K4 PCH1.K10 PCH1.K27 PCH1.K33 PCH1.K36 PCH1.K42 PCH1.K43 PCH1.L4 PCH1.L8 PCH1.L12 PCH1.L13 PCH1.L15 PCH1.L41 PCH1.M35 PCH1.M42 PCH1.N4 PCH1.N5 PCH1.N10 PCH1.N15 PCH1.N19 PCH1.N22 PCH1.N24 PCH1.N35 PCH1.N36 PCH1.N41 PCH1.P17 PCH1.P19 PCH1.P22 PCH1.P45 PCH1.R5 PCH1.R10 PCH1.R14 PCH1.R22 PCH1.R29 PCH1.R33 PCH1.R38 PCH1.T1 PCH1.T2 PCH1.T4 PCH1.T42 PCH1.U4 PCH1.U8 PCH1.U10 PCH1.U11 PCH1.U14 PCH1.U15 PCH1.U17 PCH1.U18 PCH1.U28 PCH1.U29 PCH1.U31 PCH1.U32 PCH1.U33 PCH1.U38 PCH1.V3 PCH1.V18 PCH1.V20 PCH1.V21 PCH1.V23 PCH1.V25 PCH1.V29 PCH1.V45 PCH1.W4 PCH1.W8 PCH1.W14 PCH1.W31 PCH1.W32 PCH1.W33 PCH1.W38 PCH1.Y17 PCH1.Y18 PCH1.Y20 PCH1.Y21 PCH1.Y26 PCH1.Y28 PCH1.Y29 PCIE1X.A1 PCIE1X.A4 PCIE1X.A12 PCIE1X.A15 PCIE1X.A18 PCIE1X.B4 PCIE1X.B7 PCIE1X.B13 PCIE1X.B16 PCIE1X.B18 PCIE16X.A1 PCIE16X.A4 PCIE16X.A12 PCIE16X.A15 PCIE16X.A18 PCIE16X.A20 PCIE16X.A23 PCIE16X.A24 PCIE16X.A27 PCIE16X.A28 PCIE16X.A31 PCIE16X.A34 PCIE16X.A37 PCIE16X.A38 PCIE16X.A41 PCIE16X.A42 PCIE16X.A45 PCIE16X.A46 PCIE16X.A49 PCIE16X.A51 PCIE16X.A54 PCIE16X.A55 PCIE16X.A58 PCIE16X.A59 PCIE16X.A62 PCIE16X.A63 PCIE16X.A66 PCIE16X.A67 PCIE16X.A70 PCIE16X.A71 PCIE16X.A74 PCIE16X.A75 PCIE16X.A78 PCIE16X.A79 PCIE16X.A82 PCIE16X.B4 PCIE16X.B7 PCIE16X.B13 PCIE16X.B16 PCIE16X.B18 PCIE16X.B21 PCIE16X.B22 PCIE16X.B25 PCIE16X.B26 PCIE16X.B29 PCIE16X.B32 PCIE16X.B35 PCIE16X.B36 PCIE16X.B39 PCIE16X.B40 PCIE16X.B43 PCIE16X.B44 PCIE16X.B47 PCIE16X.B49 PCIE16X.B52 PCIE16X.B53 PCIE16X.B56 PCIE16X.B57 PCIE16X.B60 PCIE16X.B61 PCIE16X.B64 PCIE16X.B65 PCIE16X.B68 PCIE16X.B69 PCIE16X.B72 PCIE16X.B73 PCIE16X.B76 PCIE16X.B77 PCIE16X.B80 Q7.C Q8.C Q10.C Q11.1 Q11.4 Q13.E Q14.E Q15.E Q16.E Q17.E Q18.E Q20.E Q24.E Q25.E Q26.E Q31.E Q32.E Q33.E Q34.C Q35.E Q36.C Q38.C QBL1.S1 QBL1.S2 QBL1.S3 QCGL1.S1 QCGL1.S2 QCGL1.S3 QCGL2.S1 QCGL2.S2 QCGL2.S3 QCGL3.S1 QCGL3.S2 QCGL3.S3 QCGL4.S1 QCGL4.S2 QCGL4.S3 QCL1.S1 QCL1.S2 QCL1.S3 QCL2.S1 QCL2.S2 QCL2.S3 QCL3.S1 QCL3.S2 QCL3.S3 QCL4.S1 QCL4.S2 QCL4.S3 QCL5.S1 QCL5.S2 QCL5.S3 QCL6.S1 QCL6.S2 QCL6.S3 QCSL1.S1 QCSL1.S2 QCSL1.S3 QN5.2 QN9.2 QN11.2 QN12.2 QN13.2 QN14.S QN15.2 QN16.2 QN17.2 QN18.2 QN19.2 QN21.2 QN22.2 QN23.2 QN25.2 QN26.2 QN27.2 QN28.2 QN29.2 QN30.2 QN31.2 QN32.2 QN34.2 QN36.2 QN37.2 QN39.2 QN40.2 R17.2 R18.2 R26.2 R29.2 R30.2 R40.2 R44.2 R63.2 R92.1 R93.1 R116.1 R118.2 R122.1 R123.2 R124.2 R134.1 R135.1 R151.2 R161.2 R166.1 R174.1 R183.2 R185.1 R197.2 R198.2 R202.1 R203.1 R216.2 R226.2 R235.2 R236.2 R237.2 R238.2 R241.2 R242.2 R243.2 R244.2 R245.2 R249.2 R250.2 R251.2 R252.2 R256.2 R257.2 R258.2 R259.2 R260.2 R266.2 R280.1 R282.2 R287.2 R288.2 R291.2 R334.1 R337.1 R339.1 R343.2 R352.1 R365.2 R372.2 R376.2 R380.2 R381.2 R383.2 R384.1 R387.2 R389.2 R393.2 R394.2 R395.1 R404.1 R417.2 R427.2 R430.2 R431.2 R448.2 R450.2 R452.2 R453.2 R460.1 R465.2 R466.2 R467.2 R475.1 R476.2 R482.2 R484.2 R495.2 R499.2 R500.1 R502.2 R506.1 R513.1 R515.2 R516.2 R532.2 R574.2 R575.2 R576.2 R585.2 R589.2 R590.2 R597.2 R598.2 R603.2 R628.2 R630.2 R633.2 R649.1 R661.2 R664.2 R667.1 R672.2 R673.2 R679.2 R693.1 R700.2 R709.2 R711.2 R712.1 R718.2 R737.2 R758.1 RJ5.3 RJ6.3 RJ7.3 RT1.1 RT3.1 SATA1.1 SATA1.4 SATA1.7 SATA1.8 SATA1.9 SATA2.1 SATA2.4 SATA2.7 SATA2.8 SATA2.9 SC1.2 SC2.2 SC3.2 SC4.2 SC5.2 SC7.2 SC8.2 SC10.2 SC15.2 SC16.2 SC17.2 SC18.2 SC19.2 SC20.1 SC21.2 SC23.2 SC24.2 SC25.1 SC26.1 SC27.2 SC28.2 SC29.1 SC30.2 SC31.2 SC32.2 SC33.2 SC34.2 SC36.2 SC37.1 SC38.1 SC39.2 SC40.2 SC41.2 SC42.2 SC43.2 SC44.2 SC45.2 SC46.2 SC47.2 SC48.2 SC49.2 SC50.2 SC51.1 SC52.1 SC53.2 SC54.2 SC55.1 SC56.2 SC57.2 SC58.2 SC59.2 SC60.2 SC61.2 SC62.2 SC63.2 SC64.2 SC69.2 SC70.2 SC71.2 SC645.2 SPI_DEBUG.9 SPIROM1.4 SQ42.E SQ43.E SR26.2 SR27.2 SR766.2 SY1.2 SY1.4 SYS_FAN.1 U1.2 U2.2 U3.8 U4.8 U5.3 U6.3 U7.15 U7.41 U8.2 U9.8 U10.8 U11.2 U12.8 U13.8 U14.2 U15.4 U15.9 U16.2 U17.2 U18.2 U19.53 U20.3 U21.33 U22.11 U23.3 U24.4 U24.9 U25.8 U25.9 U26.5 U26.9 U27.4 U27.9 U28.2 U28.14 U29.3 U30.3 U31.4 U31.11 U31.19 U31.21 U31.22 U32.2 U33.4 U33.9 U34.4 U34.5 U34.6 U35.11 U36.8 U36.9 U37.17 U38.54 U39.2 U40.3 U41.3 U42.2 U43.3 USB2_LAN.G1 USB2_LAN.G2 USB2_LAN.G3 USB2_LAN.G4 USB2_LAN.G5 USB2_LAN.G6 USB2_LAN.G7 USB2_LAN.G8 USB2_LAN.U4 USB2_LAN.U8 USB3F1.4 USB3F1.7 USB3F1.13 USB3F1.16 USB3X2.4 USB3X2.7 USB3X2.13 USB3X2.16 USB3X2.G1 USB3X2.G2 USB3X2.G3 USB3X2.G4 VGA.5 VGA.6 VGA.7 VGA.8 VGA.10 VGA.17 X1.3 Y1.3 Y1.4
P95V_PWRGD: C535.2 R512.2 U35.1
VCCIO_EN: C367.2 R339.2 R341.1 R686.2 R689.2 U28.13
VCCIO_PWRGD: C355.2 R323.1 R324.1 R325.2 U28.4
VCCIO_SENSE: CPU1.AF4 R331.2
VCCST_ON: C309.1 R297.2 U26.3
VCCST_PWRGD: R283.1 R314.2 R714.2
VCCST_PWRGD_CPU: CPU1.U2 R282.1 R283.2
VCCST_SS: C318.1 U26.6
VDDQ_PWRGD: QN31.1 R398.2 R688.1 U31.8
VSS_SA_IO_SENSE: CPU1.AE4 R300.1
24M_IN_R: SC43.1 SR17.1 SR36.1 SY1.3
662_P3: C132.1 CODEC.3
662_P4: CODEC.4 R151.1
662_P9: C130.1 CODEC.9 RJ1.2
662_P11: C131.1 CODEC.11 R168.1
95858_VDD: C92.2 R100.1 R112.2 R173.2 U19.24
+ATX_3VSB: C233.1 C510.1 C511.1 C512.1 C513.1 C522.1 C524.1 C600.1 EC33.1 ME_TEST.1 PCH1.BA24 PCH1.W15 Q27.S R294.1 R360.2 R433.1 R468.1 R523.2 R557.2 R558.2 R559.2 R572.2 R594.1 R606.2 R616.2 R623.2 R624.2 R636.2 R637.2 R640.2 R646.2 R665.2 R682.2 R685.2 R694.2 R696.2 R697.2 R699.2 R701.2 RJ2.3 SC46.1 U36.5 U36.6 U38.12
+ATX_3VSB_FB: C524.2 R468.2 R475.2 U36.7
+ATX_5VSB: ATX_POWER.9 C277.1 C284.2 C286.1 C287.1 C288.1 C532.1 C533.2 C540.1 C545.1 C546.1 C547.1 C550.1 C551.1 C595.1 D12.N D23.2 EC35.1 L9.1 Q30.S R555.2 R639.1 R649.2 R663.1 R710.2 U25.3 U25.4 U36.2 U36.3 U36.4
+DDR_VTT: C390.1 C415.1 C424.1 C425.1 C478.2 C479.2 DIMM1.120 DIMM1.240 DIMM2.120 DIMM2.240 U31.18 U31.20
+DRIVER_POWER: R167.2 R229.2 R261.2 R296.2 R391.1 Z1.2
+DVI_VGA_VCC: F1.2 PFB5.2 R11.2 R12.1 R16.1 SR2.2
+LAN_3VSB_FB: C269.2 R279.2 R280.2 U25.7
+LDOVDD: C23.1 C25.1 CODEC.29 L9.2
+R_VDD10: C155.2 C156.2 C177.2 C207.1 C212.2 C213.2 C214.1 C215.2 L11.2 U21.3 U21.8 U21.22 U21.30
+R_VDD33: C97.2 C117.2 C120.2 C172.1 C179.1 D7.N QSW1.D R132.2 R133.2 R224.1 R234.1 R247.2 U17.5 U18.5 U21.11 U21.32 USB2_LAN.14
+R_VDDREG: C203.1 C208.1 R234.2 U21.23
+RTCVCC: CLR_CMOS.1 D17.3 PCH1.BA22 R604.1 R605.1 SC56.1 SC59.1
+SPI_3P3V: C641.1 C643.1 D22.3 R740.1 R748.1 R759.1 SPI_DEBUG.4 SPIROM1.8
+USB3VCC2_2: C527.1 C590.1 EC31.1 R484.1 R582.1 U33.7 U33.8 U39.5 USB3F1.1 USB3F1.19
+USB3VCC_C1: C35.1 C36.1 EC2.1 R44.1 U14.5 U15.7 U15.8 USB3X2.1 USB3X2.10
+USBVCC0: C122.1 EC6.1 R123.1 SC15.1 U16.5 U20.7 U20.8 USB2_LAN.U1 USB2_LAN.U5
+USBVCC1: C607.1 C629.1 EC36.1 F_USB1.1 F_USB1.2 R673.1 U40.7 U40.8 U42.5
+USBVCC2: C442.1 C468.1 EC26.1 F_USB2.1 R394.1 U30.7 U30.8 U32.5
+V_3P3_LAN: C267.1 C268.1 C269.1 C273.1 R279.1 RJ2.1 U25.5 U25.6
+VCORE: C249.2 C250.1 C251.1 C252.2 C253.2 C254.1 C281.1 C283.1 C285.2 C292.1 C293.1 C294.1 C303.1 C314.1 C322.1 C323.1 C324.1 C327.1 C329.1 C330.1 CPU1.A25 CPU1.A26 CPU1.A27 CPU1.A28 CPU1.A29 CPU1.A30 CPU1.AJ11 CPU1.AJ12 CPU1.AJ13 CPU1.AJ14 CPU1.AJ15 CPU1.AJ16 CPU1.AJ17 CPU1.AJ18 CPU1.AJ19 CPU1.AJ20 CPU1.AJ21 CPU1.AJ22 CPU1.B25 CPU1.B27 CPU1.B29 CPU1.B31 CPU1.B32 CPU1.B33 CPU1.B34 CPU1.B35 CPU1.B36 CPU1.B37 CPU1.C25 CPU1.C26 CPU1.C27 CPU1.C28 CPU1.C29 CPU1.C30 CPU1.C32 CPU1.C34 CPU1.C36 CPU1.D25 CPU1.D27 CPU1.D29 CPU1.D31 CPU1.D32 CPU1.D33 CPU1.D34 CPU1.D35 CPU1.D36 CPU1.E24 CPU1.E25 CPU1.E26 CPU1.E27 CPU1.E28 CPU1.E29 CPU1.E30 CPU1.E32 CPU1.E34 CPU1.E36 CPU1.F23 CPU1.F24 CPU1.F25 CPU1.F27 CPU1.F29 CPU1.F31 CPU1.F32 CPU1.F33 CPU1.F34 CPU1.G23 CPU1.G24 CPU1.G25 CPU1.G26 CPU1.G27 CPU1.G28 CPU1.G29 CPU1.G30 CPU1.G32 CPU1.H22 CPU1.H23 CPU1.H25 CPU1.H27 CPU1.H29 CPU1.H31 CPU1.H32 CPU1.J21 CPU1.J22 CPU1.J23 CPU1.J24 CPU1.J25 CPU1.J26 CPU1.J27 CPU1.J28 CPU1.J29 CPU1.J30 CPU1.J31 CPU1.K16 CPU1.K18 CPU1.K20 CPU1.K21 CPU1.K23 CPU1.K25 CPU1.K27 CPU1.K29 CPU1.K31 CPU1.L14 CPU1.L15 CPU1.L16 CPU1.L17 CPU1.L18 CPU1.L19 CPU1.L20 CPU1.L21 CPU1.L22 CPU1.L23 CPU1.L24 CPU1.L25 CPU1.L26 CPU1.L27 CPU1.L28 CPU1.L29 CPU1.L30 CPU1.M13 CPU1.M14 CPU1.M16 CPU1.M18 CPU1.M20 CPU1.M22 CPU1.M24 CPU1.M26 CPU1.M28 CPU1.M30 EC12.1 EC14.1 EC15.1 EC17.1 EC18.1 L13.2 L14.2 L16.2 R37.2 R560.1 SC30.1 SP3.1 SP4.1 SP5.1
+VDIMM: C391.1 C392.1 C393.1 C402.1 C403.1 C404.1 C405.1 C406.1 C407.1 C409.1 C410.1 C411.1 C412.1 C413.1 C414.1 C416.1 C420.1 C421.1 C422.1 C423.1 C427.1 C432.1 C433.1 C434.1 C435.1 C436.2 C437.2 C441.2 C443.2 C446.2 C466.2 C471.2 CPU1.AT18 CPU1.AT21 CPU1.AU13 CPU1.AU15 CPU1.AU19 CPU1.AU23 CPU1.AV11 CPU1.AV17 CPU1.AV21 CPU1.AW10 CPU1.AW14 CPU1.AW25 CPU1.AY12 CPU1.AY16 CPU1.AY18 CPU1.AY23 DIMM1.51 DIMM1.54 DIMM1.57 DIMM1.60 DIMM1.62 DIMM1.65 DIMM1.66 DIMM1.69 DIMM1.72 DIMM1.75 DIMM1.78 DIMM1.170 DIMM1.173 DIMM1.176 DIMM1.179 DIMM1.182 DIMM1.183 DIMM1.186 DIMM1.189 DIMM1.191 DIMM1.194 DIMM1.197 DIMM2.51 DIMM2.54 DIMM2.57 DIMM2.60 DIMM2.62 DIMM2.65 DIMM2.66 DIMM2.69 DIMM2.72 DIMM2.75 DIMM2.78 DIMM2.170 DIMM2.173 DIMM2.176 DIMM2.179 DIMM2.182 DIMM2.183 DIMM2.186 DIMM2.189 DIMM2.191 DIMM2.194 DIMM2.197 EC24.1 L22.2 R299.2 R374.1 R375.1 R388.1 R403.2 R410.2 R428.2 R561.1 R742.1 RJ4.3 U43.6
+VGA_VCC: C1.1 C3.2 R11.1 SC1.1 SC3.1 SC7.1 SC8.1 SR1.1 SR5.1 U1.5 U2.5 U5.5 U6.5 VGA.9
-ACTIVE_P: C105.1 D8.N R126.1 USB2_LAN.13
-LINK_1G: C119.1 D10.N R133.1 R150.1 USB2_LAN.12
-LINK_100: C118.1 D9.N R132.1 R149.1 USB2_LAN.11
A20GATE: R696.1 U38.22
ACPRESENT: PCH1.BB15 R685.1
AG1_PHASE_R: C220.2 R239.1
AG2_PHASE_R: C221.2 R240.1
AG3_PHASE_R: C239.2 R264.1
ANTI_POP_L: CODEC.47 R160.2
ATX_PSON_L: ATX_POWER.16 C598.1 D25.1 QN25.1 QN26.1 R295.2 R694.1 U38.34
ATX_PSON_R: QN11.1 R295.1
ATX_PWRGD: ATX_POWER.8 C531.1 D25.2 R312.1 R347.1 R438.1 R505.2 R518.2 R621.1
ATX_PWRGD_R: C586.1 R621.2 U38.6
AUGND: AUDIO.5 AUDIO.12 AUDIO.22 AUDIO.32 AUDIO.G1 AUDIO.G2 AUDIO.G3 AUDIO.G4 C17.2 C23.2 C24.2 C25.2 C26.2 C32.2 C48.2 C50.2 C64.2 C65.2 C66.2 C67.2 C68.2 C124.1 C138.1 C154.1 C199.1 C200.1 CODEC.26 CODEC.42 D3.3 D5.3 D6.3 D11.3 D14.3 F_AUDIO.2 F_AUDIO.7 H1.1 H1.2 H1.3 H1.4 H1.5 H1.6 H1.7 H1.8 Q1.E1 Q1.E2 Q2.E1 Q2.E2 Q3.E1 Q3.E2 Q4.E1 Q4.E2 Q5.E1 Q5.E2 R38.2 R43.2 R102.2 R104.2 R105.2 R106.1 R107.2 R118.1 R136.2 R161.1 R171.2 R228.2 R231.2 R236.1
BATLOW_L: PCH1.BD13 R606.1
BCLK: C129.1 CODEC.6 R169.2
BG2_PHASE_R: C317.2 R298.1
BG3_PHASE_R: C197.2 R217.1
BOOT2B_C: C328.2 R301.2
BOOT3A_C: C243.2 R272.2
BT_DIS_L: M2_1.54 R368.2 R369.2
BT_DIS_L_R: PCH1.BC23 R368.1
BUFCLK_IN: R544.2 U37.1
BUFCLK_OUT2: C562.1 R552.1 U37.5
BUFCLK_OUT3: C557.1 R553.1 U37.3
BV1N: R187.1 R207.2 SP7.2
BV2N: R189.2 R190.1 SP9.2
BZ_P: BZ.N C601.1 D21.P RN12.2(B) RN12.4(B) RN12.6(B) RN12.8(B)
CA_REF_RC: C426.2 R387.1
CFG0: CPU1.H15 R259.1
CFG1: CPU1.F15 R260.1
CFG2: CPU1.F16 R258.1
CFG3: CPU1.H16 R256.1
CFG4: CPU1.F19 R250.1
CFG5: CPU1.H18 R244.1
CFG6: CPU1.G21 R237.1
CFG7: CPU1.H20 R235.1
CFG8: CPU1.G16 R257.1
CFG9: CPU1.E16 R251.1 R255.1
CFG10: CPU1.F17 R252.1
CFG11: CPU1.H17 R249.1
CFG12: CPU1.G20 R242.1
CFG13: CPU1.F20 R243.1
CFG14: CPU1.F21 R238.1
CFG15: CPU1.H19 R245.1
CFG_RCOMP: CPU1.M11 R287.1
CHARGE: C123.2 R134.2 U19.9
CLK0_24M: C584.1 PCH1.BC17 R662.1
CLK1_24M: C622.1 PCH1.AV19 R721.1 R722.1
CLK_REQ1_M.2_WLAN_L: PCH1.AW24 R355.1 R357.2
CLK_REQ1_WLAN_S: M2_1.53 R355.2
CLKREQ3_SSD_L: PCH1.BD25 SR33.1 SR34.2
CLKREQ3_SSD_S: M2_2.52 SR33.2
CLKRUN_L: PCH1.AW22 R695.1
COM1_RI_L: R233.2 R572.1 U38.62
CPU_24MCLK_N: CPU1.J9 PCH1.F1
CPU_24MCLK_P: CPU1.K9 PCH1.G1
CPU_BCLK_N: CPU1.W4 PCH1.H2
CPU_BCLK_P: CPU1.W5 PCH1.G2
CPU_K12: CPU1.K12 STP13.1
CPU_K13: CPU1.K13 R288.1
CPU_L12: CPU1.L12 STP12.1
CPU_PCIBCLK_N: CPU1.W2 PCH1.J1
CPU_PCIBCLK_P: CPU1.W1 PCH1.J2
CPU_PLTRST_L: PCH1.AK2 R274.1
CPU_PM_DOWN: CPU1.D8 R273.2
CPU_PM_SYNC: CPU1.E8 R486.2
CPU_PWROK: R275.1 R508.2
CPU_PWROK_RC: C257.1 CPU1.F8 R275.2
CPU_RST_L_RC: C256.1 CPU1.E7 R274.2
CPU_VIDALERT_L: CPU1.E39 SC18.1 SR11.2
CPU_VIDSCK: CPU1.E38 SC19.1 SR12.2
CPU_VIDSOUT: CPU1.E40 SC17.1 SR10.2
CPU_VSS_AB10: PCH1.AB10 R453.1
CPU_VSS_AB11: PCH1.AB11 R450.1
DCPRTC: PCH1.BA26 SC58.1
DDI1_AUXN: CPU1.C13 STP15.1
DDI1_AUXP: CPU1.B13 STP22.1
DDI1_TX_N0: C57.1 CPU1.D21
DDI1_TX_N1: C59.1 CPU1.E22
DDI1_TX_N2: C61.1 CPU1.A23
DDI1_TX_N3: C63.1 CPU1.D23
DDI1_TX_P0: C56.1 CPU1.C21
DDI1_TX_P1: C58.1 CPU1.D22
DDI1_TX_P2: C60.1 CPU1.B23
DDI1_TX_P3: C62.1 CPU1.C23
DDI2_AUXN: CPU1.B12 STP16.1
DDI2_AUXP: CPU1.A12 STP14.1
DDI2_TX_N0: C76.1 CPU1.A18
DDI2_TX_N1: C79.1 CPU1.E18
DDI2_TX_N2: C81.1 CPU1.D19
DDI2_TX_N3: C83.1 CPU1.E20
DDI2_TX_P0: C75.1 CPU1.B18
DDI2_TX_P1: C78.1 CPU1.D18
DDI2_TX_P2: C80.1 CPU1.C19
DDI2_TX_P3: C82.1 CPU1.D20
DDI3_AUX_N: CPU1.C11 SC6.1
DDI3_AUX_P: CPU1.B11 SC9.1
DDI3_TX_N0: CPU1.A14 SC12.1
DDI3_TX_N1: CPU1.B15 SC14.1
DDI3_TX_P0: CPU1.B14 SC11.1
DDI3_TX_P1: CPU1.C15 SC13.1
DDPD_CTRL_CLK: PCH1.BE5 R593.1
DDPD_CTRL_DATA: PCH1.BE6 R600.1
DDR3_DRAMRST_L: C627.1 DIMM1.168 DIMM2.168 R739.2
DDR_VOLTAGE_SEL: PCH1.AR27 R680.1
DDR_VTT_CNTL: CPU1.AC36 R311.1
DDR_VTT_CNTL_EN: C449.2 R321.2 R401.2 U31.5
DEPOP_N1: Q10.B R172.1
DEPOP_N2: Q8.B R160.1
DEPOP_N3: Q7.B Q8.E Q10.E R144.1
DEPOP_N4: C100.1 Q7.E R109.2
DEPOP_N5: Q6.B R89.2 R109.1
DEVSLP0: M2_2.38 PCH1.AG42 R550.1
DIMM_CA_CPU_VREF: C426.1 CPU1.AB40 R386.1
DIMM_DQ_A: C401.1 R375.2 R376.1 R377.1
DIMM_DQ_B: C429.1 R388.2 R389.1 R390.1
DIMM_DQ_CPU_VREF_A: C419.1 CPU1.AC40 R382.1
DIMM_DQ_CPU_VREF_B: C430.1 CPU1.AC39 R392.1
DIMM_S5: C448.2 R400.2 U31.6
DIMM_VRCA_A: R372.1 R373.1 R374.2
DIMM_VREF_CA: C397.1 C408.1 C428.1 DIMM1.67 DIMM2.67 R373.2 R386.2
DIMM_VREF_DQ_A: C398.1 C399.1 C400.1 DIMM2.1 R377.2 R382.2
DIMM_VREF_DQ_B: C438.1 C439.1 C440.1 DIMM1.1 R390.2 R392.2
DISPA_BCLK: CPU1.V3 R529.1
DISPA_BCLK_R: PCH1.AM2 R529.2
DISPA_SDI: PCH1.AN2 R284.2
DISPA_SDI_R: CPU1.U1 R284.1
DISPA_SDO: CPU1.V2 R524.1
DISPA_SDO_R: PCH1.AM1 R524.2
DM1SPD: DIMM2.236 R362.2
DM2SPD: DIMM1.236 R378.2
DMI_RX_N0: CPU1.Y4 PCH1.C27
DMI_RX_N1: CPU1.AA5 PCH1.B28
DMI_RX_N2: CPU1.AB3 PCH1.B29
DMI_RX_N3: CPU1.AC5 PCH1.B30
DMI_RX_P0: CPU1.Y3 PCH1.B27
DMI_RX_P1: CPU1.AA4 PCH1.A28
DMI_RX_P2: CPU1.AB4 PCH1.C29
DMI_RX_P3: CPU1.AC4 PCH1.A30
DMI_TX_N0: CPU1.AC1 PCH1.L27
DMI_TX_N1: CPU1.AD2 PCH1.E24
DMI_TX_N2: CPU1.AE1 PCH1.G27
DMI_TX_N3: CPU1.AF3 PCH1.L29
DMI_TX_P0: CPU1.AC2 PCH1.N27
DMI_TX_P1: CPU1.AD3 PCH1.G24
DMI_TX_P2: CPU1.AE2 PCH1.E26
DMI_TX_P3: CPU1.AF2 PCH1.K29
DPG: QN9.3 R78.2 R79.2 R80.2 R81.2 R82.2 R83.2 R84.2 R85.2
DPG2: QN5.3 R51.2 R56.2 R57.2 R58.2 R59.2 R60.2 R61.2 R62.2
DPVGA_AUX_N: SC6.2 U7.18
DPVGA_AUX_P: SC9.2 U7.19
DPVGA_DDCCLK: SR3.1 U7.12 U7.17
DPVGA_DDCSDA: SR4.1 U7.13 U7.16
DPVGA_HPD: PCH1.AV4 R17.1 U7.33
DPVGA_PWD: STP2.1 U7.31
DPVGA_RSCD: STP1.1 U7.34
DPVGA_RSET: R18.1 U7.3
DPVGA_SCL: R16.2 U7.35
DPVGA_SDA: R12.2 U7.36
DPVGA_TX_N0: SC12.2 U7.23
DPVGA_TX_N1: SC14.2 U7.26
DPVGA_TX_P0: SC11.2 U7.22
DPVGA_TX_P1: SC13.2 U7.25
DPVGA_URDBG: TP3.1 U7.24
DPWROK: C591.1 C606.1 PCH1.AV11 Q32.C R637.1 R672.1 U38.7
DQ_REF_A_RC: C419.2 R383.1
DQ_REF_B_RC: C430.2 R393.1
DRAM_RESET_L: PCH1.BC14 R737.1 R738.1 U43.1
DRAMRST: R738.2 R739.1 R742.2 U43.4
EDP_HPD: PCH1.BD7 R603.1
EDP_RCOMP: CPU1.M9 R285.1
EUP_SW_N1: C536.2 Q31.B R522.1
EUP_SW_N3: C555.1 Q31.C R462.2 R554.2 R555.1
EXTTS_SNI_DRV0_PCH: PCH1.AF41 R567.1
EXTTS_SNI_DRV1_PCH: PCH1.BD24 R658.1
FAN_CTL1: R349.2 R350.1 U38.2
FAN_CTL1_R: CPU_FAN.4 R350.2
FAN_CTL2: R537.1 R538.1 R546.2 U38.4
FAN_CTL2_OP_P2: C526.1 R537.2 U34.2
FAN_CTL2_OP_P3: R482.1 R483.1 U34.3
FAN_TAC1: C577.1 R351.2 R352.2 U38.1
FAN_TAC1_R: CPU_FAN.3 D16.P R351.1 R358.1
FAN_TAC2: C583.1 R506.2 R527.2 U38.3
FP_PWRBTN_L: C615.1 D23.3 R710.1 R756.1 U38.33
FP_RST_L: C638.1 D24.3 F_PANEL.7 PCH1.AW1 R589.1 R749.2
FRONT_JD: AUDIO.23 R140.2
FRONT_L: L5.1 Q3.C1 R74.1 R105.1
FRONT_L1: CODEC.35 EC1.1
FRONT_L2: EC1.2 R74.2
FRONT_L_P: Q3.B1 R8.2
FRONT_LL: AUDIO.24 C67.1 D5.2 L5.2
FRONT_R: L3.1 Q3.C2 R102.1 R130.1
FRONT_R1: CODEC.36 EC4.1
FRONT_R2: EC4.2 R130.2
FRONT_R_P: Q3.B2 R3.2
FRONT_RR: AUDIO.21 C65.1 D5.1 L3.2
GLAN_CLKN: PCH1.D3 U21.16
GLAN_CLKP: PCH1.F2 U21.15
GLAN_RX_C_N6: C206.2 U21.18
GLAN_RX_C_P6: C205.2 U21.17
GLAN_RX_N6: C206.1 PCH1.G22
GLAN_RX_P6: C205.1 PCH1.E22
GLAN_TX_C_N6: C198.2 U21.14
GLAN_TX_C_P6: C196.2 U21.13
GLAN_TX_N6: C198.1 PCH1.B22
GLAN_TX_P6: C196.1 PCH1.A23
GLED0: F_PANEL.2 Q40.C R760.2
GLED1: F_PANEL.4 Q39.C R754.2
GPD10_DIS_ME: PCH1.BA13 R359.2 R360.1
GPP_B5: PCH1.BC24 R607.2
GPP_B7: PCH1.AT24 R674.2
GPP_B9: PCH1.BB24 R627.2
GPP_B10: PCH1.BE25 R426.2 R608.2
GPP_B10_R: PCIE1X.B17 R426.1
GPP_B18: PCH1.BD28 R660.1 R661.1
GPP_C8: PCH1.BA41 STP66.1
GPP_C9: PCH1.AV44 STP67.1
GPP_C10: PCH1.AV43 STP68.1
GPP_C11: PCH1.AU44 TP14.1
GPP_D0: PCH1.AL39 STP53.1
GPP_D1: PCH1.AN36 STP62.1
GPP_D2: PCH1.AN38 STP63.1
GPP_D3: PCH1.AN41 STP60.1
GPP_D21: PCH1.AG44 STP51.1
GPP_D22: PCH1.AH43 STP54.1
GPP_E1: PCH1.AG35 R579.1
GPP_E2: PCH1.AG39 R565.1
GPP_E9: PCH1.AD43 R549.1
GPP_E10: PCH1.AD42 R509.1
GPP_F0: PCH1.AD35 R535.1
GPP_F1: PCH1.AD31 R534.1
GPP_F2: PCH1.AD38 R515.1 R530.1
GPP_F3: PCH1.AC43 R503.1
GPP_F4: PCH1.AB44 R504.1
GPP_F5: PCH1.AB41 R478.1
GPP_F10: PCH1.AB33 R516.1 R531.2
GPP_F11: PCH1.AB35 R510.2
GPP_F12: PCH1.AA45 R496.2
GPP_F13: PCH1.AA44 R479.2 R495.1
GPP_F15: PCH1.Y43 R449.1
GPP_F16: PCH1.Y41 R461.1 R481.1
GPP_G0: PCH1.U43 R442.2
GPP_G1: PCH1.U42 R443.2
GPP_G2: PCH1.U41 R463.2
GPP_G3: PCH1.M44 R412.2
GPP_G4: PCH1.U36 R464.2
GPP_G5: PCH1.P44 R417.1 R421.2
GPP_G6: PCH1.T45 R435.2
GPP_G7: PCH1.T44 R429.2
GPP_G12: PCH1.R39 R448.1 R451.1
GPP_G14: PCH1.R42 R430.1 R436.1
GPP_G15: PCH1.R41 R452.1 R455.1
GPP_G16_IOAC: BT1.1 BT2.1 PCH1.P43 R422.1
GPP_G18: PCH1.N43 R418.1
GPP_G20: PCH1.R35 R454.1
GPP_G21: PCH1.U35 R458.1
GPP_G22: PCH1.L44 R406.1
GPP_G23: PCH1.L43 R407.1
GPP_H0: PCH1.AT33 R632.2
GPP_H1: PCH1.AR31 R656.2
GPP_H2: PCH1.BD32 R432.2 R676.1
GPP_H2_R: PCIE16X.B17 PCIE16X.B31 PCIE16X.B48 PCIE16X.B81 R432.1
GPP_H3: PCH1.BC32 R677.2
GPP_H4: PCH1.BB31 R675.2
GPP_H5: PCH1.BC33 R612.2
GPP_H6: PCH1.BA33 R653.2
GPP_H7: PCH1.AW33 R655.2
GPP_H8: PCH1.BB33 R652.2
GPP_H9: PCH1.BD33 R629.2
GPP_H10: PCH1.BD34 STP73.1
GPP_H11: PCH1.AW35 STP64.1
GPP_H12: PCH1.BD35 R614.1 R630.1
GPP_H13: PCH1.BC35 R613.1
GPP_H14: A1.1 PCH1.BA35 R635.1
GPP_H15: A2.1 PCH1.BB36 R654.1
GPP_H16: PCH1.BD39 RJ5.2
GPP_H17: PCH1.BE34 RJ7.2
GPP_H18: PCH1.BC36 RJ6.2
GPP_H23: PCH1.BD36 R631.1
GSPI1_MOSI: PCH1.AT29 R633.1 R657.1
H_CATERR_L: CPU1.D13 STP24.1
H_PECI: CPU1.G7 R267.1 R270.1
H_PRDY_L: CPU1.B10 R569.2
H_PREQ_L: CPU1.B9 R276.2 R583.2
H_SKTOCC_L: CPU1.AB35 PCH1.Y44 Q11.2 QN13.1 R316.2
H_TCK: CPU1.F11 R266.1 R269.1
H_TDI: CPU1.G12 R271.1
H_TDO: CPU1.H13 R263.1 R265.2
H_THERMTRIP_L: CPU1.D11 R487.2 R488.1
H_TMS: CPU1.F13 R262.1
H_TRST_L: CPU1.F12 SR22.2
H_VIDALERT_L: R154.2 R155.1 SR7.2 SR11.1
H_VIDALERT_L_R: R154.1 U19.6
H_VIDSCK: R157.2 R158.1 SR8.2 SR12.1
H_VIDSCK_R: R157.1 U19.5
H_VIDSOUT: R141.2 R142.1 SR6.2 SR10.1
H_VIDSOUT_R: R141.1 U19.7
HDA_BCLK_R: PCH1.BA9 SR25.2
HDA_BITCLK: R169.1 SR25.1
HDA_RST_L: R168.2 R172.2 SR24.1
HDA_RST_L_R: PCH1.BD8 SR24.2
HDA_SDIN0: PCH1.BE7 R152.1
HDA_SDO_DIS: R353.2 SR21.1
HDA_SDO_DIS_R: R344.1 R353.1 RJ3.2
HDA_SDO_R: PCH1.BB7 SR20.2 SR21.2
HDA_SDO_R1: ME_DISABLE.2 RJ3.1
HDA_SDO_R_P1: ME_DISABLE.3 R356.1
HDA_SDOUT: CODEC.5 R344.2 SR20.1
HDA_SYNC: CODEC.10 SR23.1
HDA_SYNC_R: PCH1.BD9 SR23.2
HDD_LED_N: F_PANEL.3 Q37.C
