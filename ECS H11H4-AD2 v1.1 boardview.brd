# Allegro board ECS H11H4-AD2 v1.1 boardview.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
HDA_SYNC_R: length 5.6
  TOP w0.089: PCH1.BD9 54.65,43.22 54.46,43.03 54.46,42.58 52.88,41 v3(52.88,40.67)
  BOTTOM w0.089: v3(52.88,40.67) 52.53,41.02 v2(52.02,41.02) SR23.2
HDD_LED_N: length 5.8
  TOP w0.102: F_PANEL.3 13.06,5.72 12.01,6.76 12.01,7.62 Q37.C
HDD_LED_P: length 2.9
  TOP w0.102: F_PANEL.1 9.82,5.27 R764.2
HDMI0_CLK_N3: length 5
  TOP w0.102: CHOKE4.4 123.72,224.51 123.72,224.19 124.08,223.83 124.08,223.55 124.26,223.36 R62.1 124.08,222.88 124.08,221.26 124.39,220.95 C63.2
HDMI0_CLK_N3_R: length 8.3
  TOP w0.102: CHOKE4.3 124.02,226.93 123.65,227.3 123.65,227.74 123.78,227.87 U4.5 U4.6 123.78,229.45 123.62,229.62 123.62,229.84 123.85,230.07 124.44,230.07 125.25,230.88 125.25,231.47 125.6,231.82 HDMI2.12
HDMI0_CLK_P3: length 5
  TOP w0.102: RN2.5 123.32,224.7 123.32,224.31 123.88,223.75 123.88,223.52 123.72,223.36 R61.1 123.88,222.9 123.88,221.41 C62.2
HDMI0_CLK_P3_R: length 8.3
  TOP w0.102: CHOKE4.2 123.17,227.08 123.44,227.36 123.44,227.69 123.28,227.85 U4.4 U4.7 123.28,229.46 123.42,229.59 123.42,229.93 123.77,230.28 124.36,230.28 125.04,230.96 125.04,231.44 124.6,231.89 HDMI2.10
HDMI0_CTRLCLK: length 273.5
  TOP w0.089: PCH1.BA5 53.19,44.63 v3(53.34,44.77)
  TOP w0.102: v1(44.7,125.43) 45.67,126.39 45.67,128.12 49.78,132.23 56.13,132.23 56.31,132.41 58.29,132.41 v1(58.65,132.05) ; QN1.2 113.86,229.11 113.45,229.52 R28.2 C86.1 111.99,227.81 111.99,222.99 v1(112.17,222.81)
  BOTTOM w0.089: v3(53.34,44.77) 53.34,44.77 53.57,45 53.57,45.39 53.78,45.6 53.78,46.48 54.39,47.08 54.83,47.08 56.24,48.49 56.24,48.95
  BOTTOM w0.102: v1(58.65,132.05) 58.29,132.05 53.54,127.3 53.54,114.6 46.35,107.41 46.35,98.93 44.5,97.07 44.5,83.27 45.51,82.26 54.57,73.2 56.08,73.2 61.67,67.61 61.67,65.07 61.95,64.8 61.95,60.93 60.88,59.87 60.88,59.6 59.63,58.34 57.61,58.34 57.23,57.96 57.23,57.1 57.61,56.72 57.61,56.03 58.34,55.3 58.34,53.92 57.3,52.88 57.3,50.22 56.24,49.15 56.24,48.95 ; v1(44.7,125.43) 45.64,126.37 45.64,168.28 64.31,186.94 65.66,186.94 76.15,197.43 76.15,201.68 78.41,203.94 78.69,204.22 78.69,209.14 79.38,209.83 84.18,209.83 92.08,217.73 98.94,217.73 104.48,223.27 110.79,223.27 v2(111.15,222.91) 111.25,222.81 v1(112.17,222.81)
HDMI0_CTRLDATA: length 271.6
  TOP w0.089: PCH1.BC4 52.28,44.1 52.53,44.35 52.94,44.35 53.32,43.96 v4(53.55,43.96)
  TOP w0.102: v1(59.36,132.31) 59.03,132.64 56.21,132.64 56.03,132.46 49.68,132.46 45.42,128.19 45.42,126.92 v1(44.7,126.21) ; v1(112.8,223.22) 113.62,223.22 R35.2 113.27,223.92 112.86,223.92 112.5,224.28 C77.1 112.61,224.81 QN2.2
  BOTTOM w0.089: 56.44,49.05 56.44,48.41 54.9,46.88 54.46,46.88 53.99,46.4 53.99,45.53 53.77,45.31 53.77,44.18 v4(53.55,43.96)
  BOTTOM w0.102: v1(59.36,132.31) 59.36,131.88 58.98,131.5 58.06,131.5 54.66,128.09 v2(54.66,127.51) 53.77,126.62 53.77,114.5 46.58,107.31 46.58,98.83 44.73,96.98 44.73,83.37 45.67,82.43 53.36,74.73 54.67,73.43 56.17,73.43 61.87,67.73 61.87,65.2 62.18,64.9 62.18,60.86 61.09,59.77 61.09,59.51 59.69,58.12 57.71,58.12 57.45,57.86 57.45,57.18 57.84,56.79 57.84,56.11 58.55,55.4 58.55,53.82 57.51,52.78 57.51,50.11 56.44,49.05 ; v1(44.7,126.21) 45.42,126.92 45.42,168.38 64.24,187.2 65.58,187.2 75.92,197.54 75.92,201.77 78.25,204.1 78.46,204.31 78.46,209.23 79.29,210.06 84.09,210.06 91.99,217.96 98.84,217.96 104.38,223.49 112.52,223.49 v1(112.8,223.22)
HDMI0_HPD: length 392.7
  TOP w0.089: PCH1.AW4 52.12,45.52 v3(51.78,45.86)
  TOP w0.102: v1(31.04,25.15) 31.04,24.74 29.24,22.94 29.24,22.68 29.21,22.66 29.21,22.26 27.95,20.99 27.29,20.99 24.33,18.04 24.33,17.37 21.92,14.96 16.69,14.96 14.76,13.03 14.2,13.03 v1(13.67,13.56) ; R86.2 132.4,220.78 QN4.2 v1(132.88,222.78)
  BOTTOM w0.089: 46.96,44.86 45.57,44.86
  BOTTOM w0.102: v1(31.04,25.15) 30.78,25.4 29.74,25.4 29.31,25.83 29.31,28.14 29.03,28.42 29.03,32.93 30.45,34.35 30.45,38.63 33.5,41.68 38.94,41.68 42.11,44.86 45.57,44.86 ; v3(51.78,45.86) 51.56,45.64 47.98,45.64 47.2,44.86 46.96,44.86 ; v1(132.88,222.78) 132.52,223.14 125.93,223.14 124.69,224.38 92.46,224.38 84.96,216.89 v2(84.3,216.89) 61.77,216.89 60.45,215.57 49.1,215.57 47.8,214.27 45.87,214.27 44.12,212.52 42.9,212.52 35.79,205.41 27.43,205.41 21.54,199.52 14.6,199.52 13.17,198.08 13.17,194.58 11.89,193.29 11.89,190.83 11.15,190.09 11.15,182.17 11.89,181.43 11.89,107.68 11.89,107.3 6.32,101.74 6.32,87.38 6.73,86.97 6.73,86.72 7.54,85.91 7.54,67.54 5.2,65.19 5.2,30.82 10.08,25.93 10.08,21.95 10.87,21.16 10.87,19.08 10.57,18.77 10.57,14.5 11.51,13.56 v1(13.67,13.56)
HDMI0_HPD_CNN: length 13.3
  TOP w0.102: HDMI2.19 129.1,231.69 130.94,229.84 130.94,228.6 131.26,228.28 U8.3 132.79,228.28 C16.1 R30.1 132.54,226.26 132.54,225.07 v2(131.93,224.46) QN4.3
HDMI0_SCL: length 24.9
  TOP w0.102: HDMI2.15 127.1,231.2 128.14,230.15 129.49,230.15 130.1,229.54 130.1,228.5 129.88,228.28 U8.4 128.79,228.28 127.9,229.18 C12.1 R27.2 126.77,230.37 v1(126.77,230.38) ; QN1.3 v1(115.86,228.11)
  BOTTOM w0.102: v1(115.86,228.11) v2(118.63,228.11) 124.5,228.11 v1(126.77,230.38)
HDMI0_SDA: length 29.8
  TOP w0.102: HDMI2.16 127.6,231.41 128.3,230.71 129.41,230.71 130.53,229.59 130.53,228.14 130.05,227.66 130.05,226.72 130.39,226.38 U8.1 131.65,225.91 131.29,225.55 128.4,225.55 C31.1 R41.2 v1(126.77,224.33) ; v1(115.86,226.69) QN2.3
  BOTTOM w0.102: v1(126.77,224.33) 126.11,224.33 123.75,226.69 v2(119.91,226.69) v1(115.86,226.69)
HDMI0_TX_N0: length 4.7
  TOP w0.102: CHOKE3.4 122.1,224.66 122.1,224.28 121.87,224.05 121.87,223.52 122.03,223.36 R60.1 121.79,222.88 121.79,221.43 C61.2
HDMI0_TX_N0_R: length 8.4
  TOP w0.102: HDMI2.9 124.1,231.84 123.75,231.5 123.75,231.06 123.16,230.48 122.43,230.48 122.12,230.17 122.12,229.74 122.28,229.58 U4.9 U4.2 122.28,227.82 122.12,227.66 122.12,227.41 122.3,227.23 RN2.4
HDMI0_TX_N1: length 4.6
  TOP w0.102: CHOKE2.4 119.78,224.38 119.46,224.05 119.46,223.89 R58.1 119.51,222.88 119.51,221.43 C59.2
HDMI0_TX_N1_R: length 9.2
  TOP w0.102: HDMI2.6 122.6,231.92 122.17,231.5 122.17,231.34 122,231.17 121.5,231.17 120.66,230.33 119.74,230.33 119.56,230.15 119.56,229.87 119.72,229.71 U3.6 U3.5 119.72,227.95 119.51,227.74 119.51,227.15 119.78,226.88 CHOKE2.3
HDMI0_TX_N2: length 5
  TOP w0.102: C57.2 117.22,221.43 117.22,222.88 R56.1 117.35,223.36 117.25,223.47 117.25,223.65 117.86,224.26 117.86,224.66 CHOKE1.4
HDMI0_TX_N2_R: length 9.5
  TOP w0.102: HDMI2.3 121.1,231.99 120.68,231.57 120.68,231.37 120.37,231.06 118.47,231.06 118.08,230.68 118.08,229.84 118.22,229.71 U3.9 U3.2 118.22,227.95 118.03,227.76 118.03,227.61 117.77,227.35 117.77,227.29 118,227.06 CHOKE1.3
HDMI0_TX_P0: length 4.7
  TOP w0.102: CHOKE3.1 121.39,224.5 121.67,224.23 121.67,223.72 121.31,223.36 R59.1 121.59,222.9 121.59,221.41 C60.2
HDMI0_TX_P0_R: length 8.5
  TOP w0.102: HDMI2.7 123.1,231.92 123.55,231.47 123.55,231.15 123.08,230.68 122.34,230.68 121.92,230.26 121.92,229.74 121.78,229.61 U4.10 U4.1 121.78,227.82 121.92,227.69 121.92,227.48 121.49,227.05 RN2.2
HDMI0_TX_P1: length 4.5
  TOP w0.102: CHOKE2.1 118.93,224.33 119.25,224 119.25,223.77 R57.1 119.3,222.9 119.3,221.41 C58.2
HDMI0_TX_P1_R: length 9.1
  TOP w0.102: CHOKE2.2 118.93,227.01 119.3,227.38 119.3,227.75 119.22,227.84 U3.4 U3.7 119.22,229.68 119.35,229.82 119.35,230.23 119.65,230.53 120.57,230.53 121.41,231.37 121.91,231.37 121.97,231.43 121.97,231.55 121.6,231.92 HDMI2.4
HDMI0_TX_P2: length 5
  TOP w0.102: C56.2 117.02,221.41 117.02,222.9 R51.1 116.92,223.36 117.02,223.46 117.02,223.71 117.5,224.19 117.5,224.46 CHOKE1.1
HDMI0_TX_P2_R: length 9.6
  TOP w0.102: HDMI2.1 120.1,231.95 120.47,231.57 120.47,231.45 120.29,231.27 118.38,231.27 117.88,230.77 117.88,229.87 117.72,229.71 U3.10 U3.1 117.72,227.9 117.83,227.79 117.83,227.69 117.57,227.43 117.57,227.27 117.47,227.18 117.47,226.98 CHOKE1.2
HDMI0SCL_VCC: length 2.7
  TOP w0.102: D2.2 126.35,228.28 v1(126.11,228.52) 125.81,228.82 R27.1
HDMI0SDA_VCC: length 2.8
  TOP w0.102: D2.1 126.18,226.38 v1(125.81,226.02) R41.1
HDMI_CLK_N3: length 5.2
  TOP w0.102: C83.2 141.88,218.59 141.88,220.11 R85.1 141.88,221.02 141.88,221.25 141.43,221.71 141.43,221.84 141.83,222.24 CHOKE8.4
HDMI_CLK_N3_R: length 17.2
  TOP w0.102: HDMI1.12 150.71,231.76 150.32,231.37 150.32,230.38 148.49,228.55 141.94,228.55 141.43,228.03 141.43,227.91 141.56,227.78 U9.6 U9.5 141.56,225.94 141.45,225.83 141.45,225.3 141.83,224.93 CHOKE8.3
HDMI_CLK_P3: length 5.2
  TOP w0.102: CHOKE8.1 140.98,222.01 141.22,221.77 141.22,221.63 141.68,221.17 141.68,221.05 R84.1 141.68,220.08 141.68,218.61 C82.2
HDMI_CLK_P3_R: length 17.2
  TOP w0.102: HDMI1.10 149.71,231.78 150.11,231.37 150.11,230.46 148.4,228.75 141.86,228.75 141.22,228.12 141.22,227.94 141.06,227.78 U9.7 U9.4 141.06,226.04 141.25,225.86 141.25,225.27 140.98,225 CHOKE8.2
HDMI_CTRLCLK: length 310.4
  TOP w0.089: v4(52.35,43.36) 51.41,44.3 PCH1.BB3
  TOP w0.102: v1(59.36,133.05) 59.18,132.87 56.06,132.87 55.89,132.7 49.59,132.7 45.19,128.3 45.19,127.41 v1(44.73,126.95) ; QN7.2 149.26,221.33 R64.2 C95.1 147.04,222.41 147.04,223.39 v1(147.27,223.62)
  BOTTOM w0.089: 56.03,48.95 56.03,48.58 54.73,47.28 54.29,47.28 53.58,46.56 53.58,45.68 52.93,45.03 52.93,44.51 53.16,44.28 53.16,43.58 52.93,43.36 v4(52.35,43.36)
  BOTTOM w0.102: v1(44.73,126.95) 45.19,127.41 45.19,168.48 64.13,187.43 65.48,187.43 75.69,197.64 75.69,201.87 78.09,204.26 78.23,204.41 78.23,209.33 79.19,210.29 83.99,210.29 91.89,218.19 98.75,218.19 104.29,223.72 124.66,223.72 126.36,222.02 133.68,222.02 v2(134.11,222.45) 134.65,222.99 146.63,222.99 v1(147.27,223.62) ; v1(59.36,133.05) 58.95,133.05 53.31,127.41 53.31,114.69 46.13,107.5 46.13,99.02 44.27,97.17 44.27,83.18 45.35,82.1 54.48,72.97 55.98,72.97 61.47,67.49 61.47,64.95 61.75,64.67 61.75,61.04 60.66,59.94 60.66,59.66 59.55,58.56 57.52,58.56 57,58.04 57,57.02 57.4,56.62 57.4,55.93 58.14,55.19 58.14,54.03 57.1,52.98 57.1,50.34 56.03,49.28 56.03,48.95
HDMI_CTRLDATA: length 314.9
  TOP w0.089: PCH1.BD6 52.87,43.8 v4(52.76,43.92)
  TOP w0.102: v1(149.61,223.67) 150.06,224.13 150.54,224.13 150.87,223.8 150.87,223.67 151.22,223.33 151.22,222.11 151.01,221.9 C87.1 R65.2 149.71,220.22 150.37,219.56 151.59,219.56 QN8.2 ; v1(44.7,127.71) 44.7,128.14 49.5,132.94 55.75,132.94 55.91,133.1 58.17,133.1 58.8,133.73 v1(59.64,133.73)
  BOTTOM w0.089: 55.83,49.38 55.83,48.66 54.65,47.48 54.22,47.48 53.38,46.64 53.38,45.78 52.72,45.13 52.72,43.95 v4(52.76,43.92)
  BOTTOM w0.102: v1(44.7,127.71) 44.96,127.97 44.96,168.58 64.03,187.66 65.38,187.66 75.46,197.74 75.46,201.96 78,204.5 78,209.42 79.1,210.52 83.9,210.52 91.8,218.41 98.65,218.41 104.19,223.95 124.79,223.95 126.16,222.58 v2(131.72,222.58) 132.31,222.58 132.59,222.3 133.12,222.3 134.04,223.22 145.97,223.22 146.89,224.13 149.15,224.13 v1(149.61,223.67) ; v1(59.64,133.73) 59.31,133.73 53.09,127.51 53.09,114.79 45.9,107.6 45.9,99.12 44.04,97.26 44.04,83.08 45.34,81.79 54.38,72.75 55.89,72.75 61.26,67.37 61.26,64.82 61.52,64.57 61.52,61.11 60.45,60.05 60.45,59.77 59.46,58.78 57.42,58.78 56.77,58.13 56.77,56.91 57.2,56.48 57.2,55.83 57.94,55.09 57.94,54.13 56.9,53.09 56.9,50.44 55.83,49.38
HDMI_HPD: length 421.2
  TOP w0.089: PCH1.AY2 51.53,45.27 v4(51.76,45.04)
  TOP w0.102: v1(15.52,13.11) 16.99,14.58 21.86,14.58 24.56,17.28 24.56,17.95 27.38,20.76 28.04,20.76 29.44,22.16 29.44,22.48 29.46,22.5 29.46,22.83 32.36,25.73 32.36,29.08 31.34,30.1 30.45,30.1 v1(30.33,30.23) ; v1(152.27,224.87) 152.32,224.87 153.52,223.67 153.52,220.65 154.1,220.07 155.27,220.07 QN6.2 156.12,218.41 R103.2
  BOTTOM w0.089: v4(51.76,45.04) 48.14,45.04 47.47,44.37 45.57,44.37
  BOTTOM w0.102: v1(30.33,30.23) 29.84,30.71 29.84,33.09 30.94,34.18 30.94,38.31 33.21,40.59 36.4,40.59 36.63,40.36 37.62,40.36 37.92,40.67 38.63,40.67 42.34,44.37 45.57,44.37 ; v1(15.52,13.11) 15.27,12.85 11.53,12.85 10.08,14.3 10.08,18.97 10.41,19.3 10.41,20.87 9.63,21.66 9.63,25.35 6.81,28.17 5.66,28.17 4.67,29.16 4.67,30.69 4.65,30.72 4.65,65.29 7.09,67.73 7.09,85.72 6.27,86.53 6.27,86.59 5.77,87.1 5.77,101.83 11.43,107.49 11.43,181.18 10.69,181.91 10.69,190.32 11.43,191.06 11.43,193.55 12.7,194.82 12.7,198.27 14.43,200 21.25,200 27.65,206.4 36.07,206.4 43.05,213.39 v2(43.36,213.39) 44.22,213.39 45.67,214.83 47.62,214.83 48.84,216.05 60.27,216.05 62.03,217.81 84.53,217.81 91.62,224.89 124.88,224.89 126.1,223.67 145.77,223.67 146.69,224.59 151.99,224.59 v1(152.27,224.87)
HDMI_HPD_CNN: length 16.4
  TOP w0.102: QN6.3 154.44,221.95 R63.1 C42.1 154.44,224.73 v2(154.43,224.74) 151.96,227.21 U11.3 150.79,227.21 150.47,227.53 150.47,228.17 154.21,231.91 HDMI1.19
HDMI_SCL: length 19
  TOP w0.102: QN7.3 147.11,220.46 146.44,221.13 R68.2 C46.1 146.44,223.81 147.17,224.54 v2(147.42,224.54) 149.22,224.54 149.58,224.89 149.58,226.72 149.09,227.21 U11.4 148.71,227.78 152.21,231.28 HDMI1.15
HDMI_SDA: length 16.4
  TOP w0.102: HDMI1.16 152.71,231.19 150.09,228.57 150.09,225.98 150.76,225.31 U11.1 151.21,224.89 151.69,224.41 151.97,224.41 v2(152.55,223.82) 152.91,223.46 C47.1 R69.2 152.91,221.27 152.1,220.46 QN8.3
HDMI_TX_N0: length 5.1
  TOP w0.102: RN4.3 140.11,221.95 139.78,221.62 139.78,221.36 139.6,221.18 139.6,221.02 R83.1 139.6,220.11 139.6,218.59 C81.2
HDMI_TX_N0_R: length 17.6
  TOP w0.102: CHOKE7.3 140.05,224.87 139.85,225.07 139.85,225.73 140.06,225.94 U9.2 U9.9 140.06,227.83 139.93,227.97 139.93,228.65 140.51,229.24 147.88,229.24 148.74,230.09 148.74,231.36 149.21,231.83 HDMI1.9
HDMI_TX_N1: length 5.1
  TOP w0.102: CHOKE6.4 137.38,222.07 137.03,221.72 137.03,221.56 137.31,221.28 137.31,221.02 R81.1 137.29,220.08 137.29,218.61 C79.2
HDMI_TX_N1_R: length 19.1
  TOP w0.102: HDMI1.6 147.71,231.73 147.32,231.34 147.32,230.33 146.96,229.97 138.16,229.97 136.98,228.8 136.98,228.22 137.12,228.08 U10.6 U10.5 137.12,225.92 137.01,225.81 137.01,225.28 137.38,224.9 CHOKE6.3
HDMI_TX_N2: length 5.1
  TOP w0.102: C76.2 135.03,218.59 135.03,220.11 R79.1 135,221.05 135,221.2 135.28,221.48 135.28,221.69 135.6,222.01 CHOKE5.4
HDMI_TX_N2_R: length 18.6
  TOP w0.102: HDMI1.3 146.21,231.93 145.77,231.5 145.77,231.01 145.44,230.68 137.49,230.68 135.46,228.65 135.46,227.99 135.62,227.83 U10.9 U10.2 135.62,225.81 135.43,225.63 135.43,225.25 135.6,225.08 CHOKE5.3
HDMI_TX_P0: length 5.2
  TOP w0.102: C80.2 139.4,218.61 139.4,220.08 R82.1 139.4,221.05 139.4,221.27 139.57,221.45 139.57,221.62 139.29,221.89 RN4.1
HDMI_TX_P0_R: length 17.6
  TOP w0.102: HDMI1.7 148.21,231.7 148.54,231.37 148.54,230.18 147.79,229.44 140.43,229.44 139.73,228.74 139.73,227.99 139.56,227.83 U9.10 U9.1 139.56,225.76 139.65,225.67 139.65,225.17 139.2,224.72 CHOKE7.2
HDMI_TX_P1: length 5.1
  TOP w0.102: CHOKE6.1 136.53,221.99 136.83,221.69 136.83,221.48 137.11,221.2 137.11,221.05 R80.1 137.08,220.11 137.08,218.59 C78.2
HDMI_TX_P1_R: length 19.1
  TOP w0.102: CHOKE6.2 136.53,224.97 136.8,225.25 136.8,225.83 136.62,226.02 U10.4 U10.7 136.62,228.08 136.78,228.24 136.78,228.88 138.07,230.17 146.88,230.17 147.12,230.41 147.12,231.34 146.71,231.75 HDMI1.4
HDMI_TX_P2: length 5.1
  TOP w0.102: C75.2 134.82,218.61 134.82,220.08 R78.1 134.8,221.02 134.8,221.29 135.08,221.56 135.08,221.69 134.75,222.01 CHOKE5.1
HDMI_TX_P2_R: length 18.6
  TOP w0.102: CHOKE5.2 134.75,224.85 135.23,225.32 135.23,225.62 135.12,225.73 U10.1 U10.10 135.12,227.85 135.25,227.99 135.25,228.74 137.41,230.89 145.36,230.89 145.57,231.1 145.57,231.47 145.21,231.83 HDMI1.1
HDMISCL_VCC: length 4.6
  TOP w0.102: D4.2 146.43,218.85 v1(146.43,218.47)
  TOP w0.508: R68.1 145.93,222.18 D4.2
HDMISDA_VCC: length 17
  TOP w0.102: v1(143.1,224.43) 143.1,220.27 D4.1 ; v1(150.14,225.17) 151.1,224.21 151.1,223.77 151.5,223.37 151.5,222.21 R69.1
  BOTTOM w0.102: v1(150.14,225.17) 149.89,224.92 144.6,224.92 v2(144.12,224.43) v1(143.1,224.43)
HDPANEL_DETECT: length 387.4
  TOP w0.089: PCH1.R36 68.55,58.22 v3(69.29,58.22)
  TOP w0.102: v1(76.07,13) 76.07,12.27 78.13,10.21 78.13,7.98 v1(80.44,5.66) ; F_AUDIO.4 7.87,207.65 8.89,206.63 C154.2 9.28,204.77 D13.3 12.37,204.4 14.66,202.11 v1(18.69,202.11) ; v1(88.01,44.5) 89.56,44.5 90.37,45.31 90.37,55.37 89.48,56.26 87.89,56.26 R459.1 86.77,57.38 84,57.38 82.02,59.36 v3(81.61,59.36)
  BOTTOM w0.089: v3(69.29,58.22) 69.71,57.8 70.12,57.8 70.54,58.22 72.11,58.22 72.64,58.75 78.69,58.75 78.92,58.98 79.48,58.98
  BOTTOM w0.102: v1(80.44,5.66) 79.98,6.12 74.7,6.12 74.12,5.54 56.44,5.54 55.4,6.58 50.09,6.58 48.11,8.56 48.11,10.77 45.01,13.87 43.15,13.87 42.37,14.66 40.11,14.66 38.91,15.85 33.65,15.85 30.78,12.98 24.54,12.98 24.08,13.44 23.11,13.44 22.58,13.97 21.95,13.97 20.6,12.62 11.4,12.62 9.83,14.2 9.83,19.71 9.27,20.27 8.94,20.27 7.65,21.56 6.63,21.56 5.61,22.58 5.61,26.26 5.18,26.7 4.96,26.7 2.79,28.86 2.79,79.96 5.16,82.32 5.16,85.55 4.29,86.42 4.29,102.95 9.93,108.59 9.93,180.49 9.27,181.15 9.27,190.96 9.86,191.54 9.86,194.13 11.23,195.5 11.23,199.11 13.67,201.55 18.14,201.55 v1(18.69,202.11) ; v1(76.07,13) 76.07,12.65 76.58,12.14 77.6,12.14 78.38,11.35 79.96,11.35 81,12.4 84.71,12.4 85.06,12.75 85.06,27.56 85.93,28.42 85.93,36.96 85.34,37.54 85.34,40.79 87.76,43.21 87.76,44.25 v1(88.01,44.5) ; 79.48,58.98 81.23,58.98 v3(81.61,59.36)
HM_5VDUAL: length 11.2
  TOP w0.254: R581.1 122.43,41.31 122.91,41.78 124.21,41.78 R582.2
  TOP w0.305: R581.1 v2(121.46,41.02) 121.04,41.02 119.31,39.29 C573.1 119.15,39.29 116.98,37.12 U38.48
HM_12V: length 9.3
  TOP w0.178: 114.59,39.05 U38.50
  TOP w0.203: 114.59,39.05 115.29,39.75 117.29,39.75 C566.1 119.05,41.51 119.05,43.24 118.95,43.34
  TOP w0.254: R562.2 R563.1
HM_VCC: length 8.9
  TOP w0.305: R564.2 120.88,42.31 R568.1 120.32,41.75 120.32,41.64 C567.1 118,39.32 v2(117.98,39.32) 115.57,39.32 115.08,38.83 U38.49
HM_VCORE: length 7.3
  TOP w0.178: 113.79,39.39 U38.52
  TOP w0.203: R560.2 116.01,43.34 115.49,42.82 v1(115.49,41.61) C564.1 115.74,40.49 114.88,40.49 113.79,39.39
HM_VDIMM: length 7.9
  TOP w0.178: 114.19,39.26 U38.51
  TOP w0.203: R561.2 117.57,43.34 117.88,43.03 117.88,41.48 C565.1 116.48,40.08 115.01,40.08 114.19,39.26
HSODN5: length 10
  TOP w0.102: C238.2 43.01,181.23 42.54,181.7 42.18,181.7 41.5,182.37 40.69,182.37 39.78,183.29 38.38,183.29 38.37,183.27 35.9,183.27 35.75,183.12 35.75,182.59 35.95,182.39 PCIE1X.B15
HSODP5: length 10
  TOP w0.102: PCIE1X.B14 34.65,183.24 35.58,183.24 35.82,183.48 38.28,183.48 38.3,183.49 39.86,183.49 40.78,182.58 41.59,182.58 42.26,181.9 42.54,181.9 43.01,182.37 C236.2
I2CLK: length 5.6
  TOP w0.102: R176.1 159.53,206.2 162.5,206.2 163.47,207.18 U19.42
I2DATA: length 6.7
  TOP w0.102: U19.43 163.87,207.25 162.59,205.97 159.97,205.97 159.45,205.45 R177.1
ISEN1_A: length 36
  TOP w0.203: R90.2 C70.2 172.83,219.02 v1(172.36,219.02) 172.11,219.02 170,216.92 168.81,216.92 167.42,215.53 167.17,215.53 166.27,214.64 U19.17
  TOP w0.254: v1(180.62,209.19) 181.33,208.48 R162.2 ; R90.2 174.88,219.26 174.88,220.53 R72.1 ; R113.2 v1(181.33,215.14)
  BOTTOM w0.254: v1(172.36,219.02) 175.21,219.02 179.1,215.14 v1(181.33,215.14) 182.09,214.38 182.09,213.2 184.12,211.17 184.12,209.42 183.9,209.19 v2(181.43,209.19) v1(180.62,209.19)
ISEN1_B: length 13.3
  TOP w0.203: C167.2 168.64,205.33 168.64,205.93 167.07,207.49 U19.51
  TOP w0.254: C167.2 R179.2 R188.1 170.54,203.17 171.25,202.46 v1(171.25,202.34) ; v1(175.06,203.12) 174.89,203.3 R190.2
  BOTTOM w0.254: v1(175.06,203.12) 174.96,203.02 v2(174.17,203.02) 171.88,203.02 171.25,202.39 v1(171.25,202.34)
ISEN2_A: length 38.8
  TOP w0.203: R98.2 181.73,220.17 180.93,220.17 R96.2 C74.2 177.47,219.42 ; U19.16 166.67,214.53 167.34,215.19 167.61,215.19 168.96,216.53 170.13,216.53 171.55,217.96 176.25,217.96 177.47,219.18 177.47,219.42 ; 177.47,219.42 177.32,219.58 177.32,221.06 174.83,223.55 174.83,224.02 R48.2
  TOP w0.254: R98.2 183.27,220.22 185.65,220.22 186.41,219.46 v2(186.41,216.36) 186.41,214.6 R148.2
ISEN2_B: length 17.1
  TOP w0.203: U19.52 167.47,207.66 168.76,206.38 170.97,206.38 172.12,205.23 v1(172.27,205.23)
  TOP w0.254: R187.2 169.47,203.33 v1(168.78,204.01) ; R191.1 175.89,203.45 175.89,204.95 175.39,205.45 R180.2 C168.2 172.5,205.45 v1(172.27,205.23)
  BOTTOM w0.254: v2(171.17,205.23) 171.15,205.23 ; 171.15,205.23 170.36,205.23 169.14,204.01 v1(168.78,204.01) ; 171.15,205.23 171.15,205.23 v1(172.27,205.23)
ISEN3_A: length 41.4
  TOP w0.203: 180.19,217.55 171.65,217.55 170.26,216.15 169.09,216.15 167.79,214.86 167.51,214.86 167.07,214.42 U19.15 ; R47.2 173.89,225.17 174.42,225.17 175.16,224.43 175.16,223.7 178,220.85 v1(178,220.14) ; C109.2 R128.2
  TOP w0.254: 180.19,217.55 v1(180.39,217.55) 180.7,217.25 180.7,214.98 C109.2 180.7,213.71 180.7,212.44 R146.2 ; R128.2 182.87,214.34 185.65,217.12 185.65,218.72 184.94,219.42 R99.1
  BOTTOM w0.254: v1(180.39,217.55) 180.39,217.63 v2(179.2,218.82) 178,220.01 v1(178,220.14)
ISEN3_B: length 2.4
  TOP w0.203: R173.1 169.14,207.14 167.99,208.29 U19.1
ISEN4_A: length 14.8
  TOP w0.203: R112.1 179.34,217.22 171.83,217.22 170.38,215.77 170.38,214.91 169.9,214.43 167.79,214.43 U19.14
ISL95858_VIN: length 11.3
  TOP w0.203: 163.87,206.44 164.27,206.84 U19.44
  TOP w0.508: R181.1 156.9,204.98 v2(157.02,204.85) 157.53,204.34 161.36,204.34 C158.2 162.41,204.98 163.87,206.44
ISOLATEB: length 7.9
  TOP w0.102: U21.20 51.57,198.63 50.6,197.66 49.99,197.66 49.1,196.78 R226.1 49.71,195.75 49.71,194.67 v2(49.53,194.49) 49.53,194.19 R232.1
ITP_PMODE: length 19
  TOP w0.089: 45.06,45.92 47.32,45.92 48.51,47.12 50.9,47.12 51.02,47 PCH1.AT2
  TOP w0.102: 45.06,45.92 41.91,45.92 39.42,43.43 39.42,42.32 38.58,41.48 35.86,41.48 TP15.1
JDREF: length 2.3
  TOP w0.254: R106.2 12.98,218.8 CODEC.40
JP1: length 6.3
  TOP w0.102: U38.24 111.79,28.53 111.1,27.84 109.25,27.84 v1(108.97,27.56) R700.1 R699.1
JP2: length 8.4
  TOP w0.102: R559.1 109.83,43.36 v1(109.46,42.99) 109.19,42.72 109.19,41.43 R576.1 109.15,40.46 110.79,40.46 112.19,39.07 U38.56
JP3: length 8.9
  TOP w0.102: U38.58 111.39,39.13 v1(110.85,39.67) 110.44,40.08 108.05,40.08 107.54,40.59 R575.1 108.05,41.43 108.05,43.08 R558.1
JP4: length 9.3
  TOP w0.102: U38.60 110.59,39.2 110.03,39.75 107.21,39.75 v2(106.93,40.03) 106.4,40.56 R574.1 107.04,41.56 107.04,43.21 R557.1
KBRST_L: length 147.5
  TOP w0.102: v1(54.08,19.35) 54.56,18.87 54.56,17.78 54.41,17.63 54.41,14.86 53.52,13.97 52.76,13.97 52.07,13.28 52.07,12.29 51.74,11.96 50.93,11.96 48.84,9.88 v1(48.82,9.88) ; R648.2 53.84,30.77 55.07,29.54 55.07,28.5 54.58,28.02 53.87,28.02 52.63,26.77 52.63,26.03 52.3,25.7 51.58,25.7 v1(51.39,25.9) ; v1(112.09,31.34) 111.33,31.34 110.59,30.6 U38.21
  BOTTOM w0.102: v1(51.39,25.9) 51.39,23.52 v2(51.43,23.47) 51.43,22.51 54.08,19.87 v1(54.08,19.35) ; v1(112.09,31.34) 112.09,27.53 112.47,27.15 113.26,27.15 115.93,29.82 121.49,29.82 122.61,28.7 122.61,28.19 122.22,27.81 122.22,13.72 121.74,13.23 121.74,12.14 122.33,11.56 122.33,9.25 121.41,8.33 114.3,8.33 112.67,9.96 106.98,9.96 104.8,7.77 102.84,7.77 100,4.93 81.91,4.93 80.49,6.35 73.96,6.35 73.81,6.5 73.41,6.5 73.13,6.22 56.44,6.22 55.63,7.04 50.44,7.04 48.82,8.66 v1(48.82,9.88)
KBRST_L_RC: length 20.3
  TOP w0.089: v3(58.01,46.74) 58.35,47.07 PCH1.AT17
  TOP w0.102: v1(55.42,32.89) 54.58,32.05 C594.1 R648.1 R647.1
  BOTTOM w0.089: v3(58.01,46.74) 58.55,46.2 58.55,44.6 58.76,44.39 58.81,44.34 58.81,43.62 58.29,43.1 58.29,41.15 57.63,40.5 57.63,38.02 55.93,36.32
  BOTTOM w0.102: 55.93,36.32 55.17,35.56 55.17,33.15 v1(55.42,32.89)
KCLK: length 4.2
  TOP w0.102: R646.1 117.34,33.44 U38.39
KDAT: length 4.8
  TOP w0.102: U38.38 117.13,33.04 118.57,31.6 v2(118.57,31.37) 118.57,31.15 R665.1
LAN_LED0: length 17.5
  TOP w0.102: R149.2 65,207.01 58.09,200.1 55.02,200.1 54.18,200.93 U21.27
LAN_LED1: length 18.3
  TOP w0.102: U21.26 54.2,200.53 54.89,199.85 58.22,199.85 v2(66.4,208.03) R150.2
LAN_LED2: length 284
  TOP w0.102: v1(27.61,181.51) 27.97,181.51 28.45,181.03 28.45,180.75 28.75,180.44 29.29,180.44 29.72,180.01 29.72,179.81 31.67,177.85 35.03,177.85 37.01,175.87 40.23,175.87 40.92,176.56 51.43,176.56 52.48,177.6 v1(52.48,178.74) ; U21.25 54.22,200.13 54.76,199.59 59.11,199.59 v1(61.19,201.68) ; v1(28.91,19.84) 27.75,19.84 25.48,17.57 25.48,16.9 24.36,15.78 24.36,13.34 25.25,12.45 Q38.B ; v1(77.04,204.57) 77.57,205.11 R126.2
  BOTTOM w0.102: v1(77.04,204.57) 75.41,202.95 73.02,202.95 72.39,202.31 67.03,202.31 66.52,202.82 62.33,202.82 v2(61.82,202.31) v1(61.19,201.68) 60.83,201.32 60.83,195.33 61.49,194.67 61.49,186.11 55.04,179.65 53.39,179.65 v1(52.48,178.74) ; v1(27.61,181.51) 27.61,181.38 v2(26.95,180.72) 26.34,180.11 26.34,140.15 27,139.49 27,128.25 22.76,124.01 22.76,114.17 10.72,102.13 10.72,80.65 13.54,77.83 13.54,74.78 14.53,73.79 14.53,67.74 15.21,67.06 15.21,62.66 14.35,61.8 14.35,58.29 15.37,57.28 15.37,55.53 14.45,54.62 14.45,54.17 15.54,53.08 15.54,50.97 20.02,46.5 20.02,31.83 21.01,30.84 21.01,29.73 21.74,29 21.74,27.05 21.44,26.75 21.44,24.74 26.67,19.51 28.57,19.51 v1(28.91,19.84)
LAN_MOS: length 5
  TOP w0.102: v2(52.27,186.36) 52.1,186.54 52.1,187.76 52.55,188.21 C228.2 R241.1 53.6,189.52 QSW1.G
LAN_PWR_CTRL: length 316.4
  TOP w0.102: D15.2 5.26,147.3 5.26,146.13 v1(5.08,145.95) ; v1(123.98,12.47) v1(122.22,12.47) ; R701.1 111.53,26.84 112.37,27.69 v1(112.75,27.69) 112.75,28.3 112.59,28.46 U38.26
  BOTTOM w0.102: v1(5.08,145.95) 7.7,145.95 8.74,144.91 8.74,142.01 7.72,141 5.05,141 2.64,138.58 2.64,131.24 1.98,130.58 1.98,86.94 3.51,85.42 3.51,84.25 4.24,83.52 4.24,82.73 1.88,80.37 1.88,19.94 3.33,18.49 3.33,16.97 9.93,10.36 30.23,10.36 33.07,13.21 39.19,13.21 39.4,13 41.66,13 42.44,12.22 44.3,12.22 46.41,10.12 46.41,5.97 47.9,4.47 53.14,4.47 53.75,3.86 77.14,3.86 77.65,4.37 78.71,4.37 79.83,3.25 100.79,3.25 103.3,5.77 105.41,5.77 107.29,3.89 114.58,3.89 116.13,5.44 122.91,5.44 124.18,6.71 124.18,12.27 v1(123.98,12.47) ; v1(122.22,12.47) 122.48,12.73 122.48,27.71 122.83,28.07 122.83,28.8 121.46,30.18 115.24,30.18 v2(113.54,28.47) v1(112.75,27.69)
LAN_RST_L_R: length 14.7
  TOP w0.102: U21.19 51.17,198.59 50.52,197.94 49.91,197.94 49.12,197.15 48.29,197.15 48.03,196.9 R225.1 47.52,195.85 47.52,193.32 v2(47.8,193.04) 47.96,193.04 49.6,191.4 C218.2 51.16,189.71 BT1.3
LAN_WAKE: length 15.8
  TOP w0.089: 53.87,36.96 53.87,37.41 55.26,38.8
  TOP w0.102: 53.87,36.96 53.87,35.81 53.24,35.18 53.24,34.46 R623.1 52.81,33.62 52.81,32.77 52.55,32.51 51.99,32.51 v2(51.36,31.88) 51.23,31.74 R645.2 ; 55.26,38.8 55.6,39.14 56.21,39.14 56.46,39.4 56.46,41.12 56.11,41.48 56.11,42.97 55.98,43.1 55.98,43.13 55.98,43.23 PCH1.BD11
LAN_WAKE_L: length 270.9
  TOP w0.102: v1(50.42,30) R645.1 ; v1(51.16,177.83) 50.37,177.04 40.51,177.04 38.35,179.2 36.3,179.2 35.43,178.33 32.79,178.33 30.2,180.92 v1(28.98,180.92) ; U21.21 51.97,198.68 50.27,196.98 R224.2 50.83,195.83 50.83,194.05 R233.1 50.59,192.9 50.59,191.2 51.84,189.94 51.84,188.26 v1(51.03,187.45) ; v1(13.54,46.3) 14.27,46.3 18.59,50.62 18.59,66.01 26.95,74.37 26.95,82.74 20.26,89.42 20.26,97.77 19.54,98.5 19.54,103.3 17.86,104.98 17.86,106.9 24.26,113.3 24.26,115.44 24.46,115.64 v1(24.46,116.18) ; v1(23.83,17.55) 23.83,17.86 27.19,21.22 27.85,21.22 28.98,22.35 28.98,23.01 30.33,24.36 v1(30.33,24.92)
  BOTTOM w0.102: v1(23.83,17.55) 23.57,17.3 20.6,17.3 18.41,19.48 18.41,22.58 16.46,24.54 16.46,27.58 15.57,28.47 15.57,44.7 13.97,46.3 v1(13.54,46.3) ; v1(28.98,180.92) 29.34,180.57 29.34,179.3 27.03,176.99 27.03,140.48 27.76,139.74 27.76,128 23.44,123.68 23.44,117.2 v1(24.46,116.18) ; v1(50.42,30) 50.06,30 46.43,26.37 45.31,26.37 44.77,25.83 43.81,25.83 43.18,26.47 41.83,26.47 41,27.31 39.62,27.31 39.14,27.79 38.2,27.79 37.26,26.85 36.09,26.85 v2(35.99,26.95) 35.56,27.38 34.11,27.38 31.39,24.66 30.58,24.66 v1(30.33,24.92) ; v1(51.03,187.45) 51.03,177.95 v1(51.16,177.83)
LAN_XTAL1: length 9.9
  TOP w0.152: U21.28 54.6,201.33 55.4,200.53 56.77,200.53 v1(57.2,200.96) ; R219.2 v1(59.46,197.01)
  BOTTOM w0.152: v1(59.46,197.01) v2(59.46,198.35) 59.46,198.93 57.43,200.96 v1(57.2,200.96)
LAN_XTAL2: length 17.8
  TOP w0.152: v1(57.91,201.51) 57.89,201.52 56.9,201.52 56.31,200.94 55.7,200.94 54.91,201.73 U21.29 ; X1.2 61.81,193.73 C209.2 60.99,194.09 60.99,194.08 60.78,194.08 v1(60.1,194.77)
  BOTTOM w0.152: v1(60.1,194.77) 60.1,198.91 57.91,201.09 v1(57.91,201.51)
LED_BT: length 135.7
  TOP w0.102: R732.1 36.21,21.11 v1(35.53,21.79) ; v1(31.06,118.26) 31.57,117.75 34.16,117.75 35.46,119.05 41.88,119.05 42.69,119.85 M2_1.16
  BOTTOM w0.102: v1(31.06,118.26) 31.06,117.83 20.52,107.29 20.52,106.3 19.25,105.03 17.75,105.03 13.28,100.56 13.28,84.07 17.14,80.21 17.14,69.06 17.88,68.33 17.88,51.94 22.38,47.45 22.38,33.23 23.85,31.76 23.85,30.69 23.93,30.61 23.93,30.61 24.16,30.38 24.16,27.33 23.52,26.7 23.52,26.26 24.46,25.32 24.46,23.83 27.33,20.96 27.61,20.96 28.63,21.97 30.76,21.97 31.39,22.61 33.68,22.61 v2(34.42,21.87) 34.49,21.79 v1(35.53,21.79)
LED_BT_R: length 2.2
  TOP w0.102: R732.2 36.25,22.91 35.76,23.39 Q36.B
LED_WLAN: length 136
  TOP w0.102: v1(32.89,22.12) 32.94,22.12 33.68,21.39 R733.1 ; M2_1.6 45.19,119.91 44.95,119.67 42.94,119.67 42.04,118.77 35.53,118.77 34.29,117.53 30.78,117.53 v1(30.4,117.91)
  BOTTOM w0.102: v1(30.4,117.91) 30.4,117.5 20.27,107.37 20.27,106.38 19.16,105.27 17.67,105.27 13.06,100.66 13.06,83.97 16.87,80.16 16.87,68.96 17.65,68.17 17.65,51.85 22.15,47.35 22.15,33.14 23.62,31.66 23.62,30.58 23.93,30.28 23.93,27.48 23.29,26.85 23.29,26.06 24.18,25.17 24.18,23.75 27.2,20.73 27.71,20.73 28.73,21.74 v2(32.05,21.74) 32.44,22.12 v1(32.89,22.12)
LED_WLAN_R: length 8.1
  TOP w0.102: R733.2 33.68,22.76 33.53,22.91 33.53,24.89 35.79,27.15 35.79,27.89 v2(34.57,27.89)
LGATE1_A: length 72.3
  TOP w0.203: U19.28 161.4,213.2 160.2,214.4 v1(160.2,214.48)
  TOP w0.635: QCL1.G 113.36,184.28 v1(113.23,184.4) ; QCL2.G v1(113.39,192.41)
  BOTTOM w0.508: v1(113.39,192.41) 114.46,193.48 114.46,197.29 115.8,198.63 120.04,198.63 121.56,200.15 122.81,200.15 129.48,206.82 141.26,206.82 143.69,209.25 145.59,209.25 149.86,213.51 156.87,213.51 157.84,214.48 v1(160.2,214.48)
  BOTTOM w0.635: v1(113.23,184.4) 113.56,184.4 114.53,185.37 v2(114.53,190.04) 114.53,191.26 v1(113.39,192.41)
LGATE1_B: length 110.2
  TOP w0.203: U19.34 161.4,210.8 161.14,210.54 v1(160.91,210.54)
  TOP w0.508: v1(153.64,192.96) 174.75,192.96 v1(174.83,192.89)
  TOP w0.635: QCGL2.G v1(181.46,163.83) ; QCGL1.G v1(173.33,163.83)
  BOTTOM w0.508: v1(160.91,210.54) 160.96,210.49 161.04,210.49 161.65,209.88 161.65,207.98 158.18,204.51 158.18,203.42 153.9,199.14 153.9,197.1 155.17,195.83 155.17,193.93 154.2,192.96 v1(153.64,192.96) ; v1(181.46,163.83) 182.85,162.43 186.16,162.43 191.21,167.49 191.21,172.97 192.66,174.42 192.66,182.22 189.86,185.03 176.14,185.03 174.83,186.33 v1(174.83,192.89)
  BOTTOM w0.635: v1(181.46,163.83) 180.44,162.81 v2(179.4,162.81) 174.35,162.81 v1(173.33,163.83)
LGATE2_A: length 53.6
  TOP w0.203: U19.33 161.26,211.2 161.14,211.07 160.55,211.07 159.97,210.49
  TOP w0.508: 159.97,210.49 159.66,210.19 v1(157.2,210.19)
  TOP w0.635: v1(131.01,192.05) 131.37,192.41 QCL4.G ; QCL3.G v1(131.17,184.28)
  BOTTOM w0.508: v1(131.01,192.05) 132.44,193.47 v2(132.44,197.61) 132.44,199.01 133.58,200.15 138.9,200.15 144.95,206.2 147.04,206.2 151.03,210.19 v1(157.2,210.19)
  BOTTOM w0.635: v1(131.01,192.05) 132.31,190.75 132.31,185.42 v1(131.17,184.28)
LGATE2_B: length 25.1
  TOP w0.254: U27.5 v1(192.51,143.32)
  TOP w0.635: QCGL4.G v1(173.33,146.3) ; QCGL3.G v1(181.46,146.3)
  BOTTOM w0.635: v1(192.51,143.32) 190.15,145.67 186.41,145.67 185.9,145.16 182.6,145.16 v1(181.46,146.3) 180.25,145.09 v2(179.32,145.09) 173.78,145.09 173.33,145.54 v1(173.33,146.3)
LGATE3_A: length 22.7
  TOP w0.254: U24.5 v1(191.1,178.75)
  TOP w0.635: QCL6.G v1(173.2,181.74) ; QCL5.G v1(181.33,181.74)
  BOTTOM w0.635: v1(173.2,181.74) 174.09,180.85 v2(179.12,180.85) 180.44,180.85 v1(181.33,181.74) 182.4,180.67 186.08,180.67 188,178.75 v1(191.1,178.75)
LINE1_JD: length 92.6
  TOP w0.254: R139.2 25.37,211.53 25.7,211.2 34.4,211.2 36.02,212.82 36.02,224.11 29.01,231.12 29.01,236.68 32.77,240.44 40.51,240.44 42.37,238.58 49.76,238.58 50.37,237.97 57.66,237.97 58.49,237.14 58.49,235.68 56.62,233.81 47.98,233.81 47.22,233.05 47.22,230.89 50.84,227.26 AUDIO.33
LINE1_L: length 71.8
  TOP w0.254: v1(30.28,223.27) 30.27,223.27 R49.2 ; v1(43.65,219.14) L6.1 44.46,219.04 R107.1 ; Q4.C1 19.64,237.02 19.99,236.68 v1(21.72,236.68)
  BOTTOM w0.254: v1(43.65,219.14) v2(46.3,221.79) 49.68,225.17 49.68,228.6 47.14,231.14 47.14,233.81 40.39,240.56 25.2,240.56 21.72,237.08 v1(21.72,236.68) 22.94,235.46 22.94,233.78 30.56,226.16 30.56,223.55 v1(30.28,223.27)
LINE1_L1: length 5.1
  TOP w0.254: CODEC.23 23.28,219.8 24.1,220.62 24.1,222.38 C44.2
LINE1_L2: length 1.3
  TOP w0.254: R49.1 C44.1
LINE1_L_P: length 1.4
  TOP w0.254: R9.2 20.29,234.92 Q4.B1
LINE1_LL: length 9.5
  TOP w0.254: AUDIO.34 48.34,223.75 47.11,222.52 D6.2 46.87,220.57 C68.1 44.58,220.57 L6.2
LINE1_R: length 68.8
  TOP w0.254: 51.49,217.91 51.84,218.26 51.84,218.26 v1(52.3,218.72) ; 51.49,217.91 L4.1 ; 51.49,217.91 R104.1 ; Q4.C2 21.1,235.75 21.64,235.75 v1(21.67,235.73) ; v1(29.87,225.22) 29.79,225.3 R39.2
  BOTTOM w0.254: v1(52.3,218.72) 51.33,219.68 v2(51.33,221.67) 51.33,222.73 52.1,223.49 52.1,228.19 49.63,230.66 49.63,232.13 40.62,241.14 24.96,241.14 21.03,237.21 21.03,236.36 v1(21.67,235.73) 22.38,235.02 22.38,233.5 29.87,226.01 v1(29.87,225.22)
LINE1_R1: length 6.4
  TOP w0.254: CODEC.24 23.1,220.38 23.57,220.85 23.57,223.88 C27.2
LINE1_R2: length 1.3
  TOP w0.254: R39.1 C27.1
LINE1_R_P: length 1.4
  TOP w0.254: R4.2 20.29,238.28 Q4.B2
LINE1_RR: length 13.6
  TOP w0.254: L4.2 51.33,220.72 C66.1 49.4,220.72 D6.1 49.01,222.77 50.39,224.16 53.31,224.16 AUDIO.31
LINE2_JD: length 36.6
  TOP w0.254: R31.1 11.32,226.49 4.34,226.49 2.74,224.89 2.74,205.4 4.43,203.71 5.05,203.71 5.84,202.92 5.84,201.27 F_AUDIO.10
LINE2_L: length 98.4
  TOP w0.254: Q2.C1 13.32,237.6 v1(13.11,237.39) ; F_AUDIO.9 3.88,199.36 C199.2 4.27,197.57 D14.2 5.17,196.46 v1(4.98,196.27) 4.08,195.37 R228.1 ; R137.2 v1(27.2,212.72)
  BOTTOM w0.254: v1(4.98,196.27) 3.28,197.97 3.28,210.87 3.78,211.38 7.47,211.38 8.15,210.69 8.15,209.17 9.3,208.03 11.46,208.03 12.29,208.86 12.29,211.53 11.25,212.57 11.25,215.67 12.73,217.14 21.44,217.14 25.86,212.72 v1(27.2,212.72) 28.27,213.79 30.33,213.79 31.39,214.86 31.39,217.09 28.8,219.68 28.8,225.6 20.92,233.49 19.24,233.49 15.34,237.39 v1(13.11,237.39)
LINE2_L1: length 10.8
  TOP w0.254: CODEC.14 23.26,215.3 23.55,215.01 23.55,214.09 24.15,213.49 EC5.1
LINE2_L2: length 6.1
  TOP w0.254: R137.1 30.23,212.72 30.61,212.34 33.23,212.34 EC5.2
LINE2_L_P: length 1.4
  TOP w0.254: Q2.B1 14.45,234.92 R7.2
LINE2_R: length 110.1
  TOP w0.254: v1(15.1,236.46) Q2.C2 ; F_AUDIO.5 5.64,206.2 7.54,206.2 8.15,205.59 8.15,201.22 8.66,200.71 8.66,198.27 C200.2 7.97,197.57 D14.1 7.07,195.42 v1(7.32,195.17) 7.32,193.94 R231.1 ; v1(28.1,221.36) R77.2
  BOTTOM w0.254: v1(15.1,236.46) 15.51,236.46 19.05,232.92 20.73,232.92 28.1,225.55 v1(28.1,221.36) 28.1,219.55 30.89,216.76 30.89,215.16 30.05,214.33 25.43,214.33 22.07,217.68 12.45,217.68 10.74,215.98 10.74,212.19 11.73,211.2 11.73,209.12 11.25,208.64 9.55,208.64 8.71,209.47 8.71,211.02 7.67,212.06 3.51,212.06 2.69,211.25 2.69,196.29 3.81,195.17 v1(7.32,195.17)
LINE2_R1: length 17
  TOP w0.254: CODEC.15 23.52,215.8 24.08,215.24 24.08,214.41 24.47,214.02 30.66,214.02 32.38,215.75 32.38,220.02 EC3.1
LINE2_R2: length 6.4
  TOP w0.254: R77.1 30.45,221.84 33.06,221.84 EC3.2
LINE2_R_P: length 1.4
  TOP w0.254: Q2.B2 14.45,238.28 R2.2
LPC_24M: length 102.9
  TOP w0.102: R721.2 52.38,21.82 53.01,21.82 54.08,20.75 54.08,20.42 55.07,19.43 55.07,15.11 v1(55.17,15.01) ; LPC_DEBUG.1 94.39,23.5 94.97,23.5 95.23,23.24 95.23,21.99 94.86,21.62 93.46,21.62 92.68,20.84 92.68,20.15 92.49,19.96 92.11,19.96 91.94,20.14 91.94,21.31 92.68,22.05 R709.1 C619.2 93.83,25.43 v1(97.05,25.43)
  BOTTOM w0.102: v1(97.05,25.43) 97.05,11.35 96.39,10.69 92.3,10.69 91.49,9.88 90.96,9.88 90.28,10.56 85.73,10.56 arc(85.45,10.85) 85.73,11.13 89.92,11.13 arc(90.17,11.38) 89.92,11.63 86.71,11.63 arc(86.44,11.9) 86.71,12.18 88.75,12.18 arc(89.03,12.45) 88.75,12.73 86.39,12.73 85.29,11.63 81.53,11.63 80.54,10.64 78,10.64 77.22,11.43 76.28,11.43 73.38,14.33 55.85,14.33 v1(55.17,15.01)
LPC_FRAME_L: length 93.8
  TOP w0.089: 58.34,36.96 58.34,39.52 58.5,39.68 58.5,42.14 58.32,42.32 58.32,42.66 PCH1.BE16
  TOP w0.102: v1(55.96,20.83) 55.96,23.37 57.43,24.84 57.43,25.98 57.89,26.44 57.89,31.78 58.39,32.28 58.39,36.91 58.34,36.96 ; v1(106.55,28.52) 106.86,28.83 106.86,30.66 107.15,30.95 U38.16 ; v1(79.45,19.61) 79.45,19.28 80.85,17.88 88.65,17.88 91.26,20.5 LPC_DEBUG.3 91.26,24.84 90.88,25.22 90.88,26.19 91.69,27 97.97,27 99.06,25.91 101.65,25.91 102.91,24.65 v1(102.91,24.38)
  BOTTOM w0.102: v1(79.45,19.61) 79.58,19.74 79.58,20.93 79.1,21.41 75.56,21.41 74.88,20.73 74.88,19.86 74.35,19.33 72.06,19.33 71.6,18.87 69.93,18.87 68.91,19.89 61.59,19.89 60.4,21.08 56.21,21.08 v1(55.96,20.83) ; v1(102.91,24.38) 103.77,25.25 104.32,25.25 104.85,25.78 104.85,27.08 106.3,28.52 v1(106.55,28.52)
LPC_LAD0: length 96.2
  TOP w0.089: v3(60.33,47.09) 60.37,47.07 PCH1.AT22
  TOP w0.102: v1(77.34,18.72) 77.34,20.6 78.08,21.34 79.53,21.34 LPC_DEBUG.11 81.76,23.57 81.76,26.75 83.29,28.27 98.68,28.27 99.74,27.2 102.64,27.2 v1(102.9,26.95) ; U38.17 108.9,31.73 v1(109.02,31.85) ; v1(57.33,20.17) 57.33,23.01 58.8,24.49 58.8,26.26 v1(58.52,26.54)
  BOTTOM w0.089: 58.8,36.32 58.8,39.95 59.59,40.74 59.59,41.2 60.2,41.81 60.2,42.51 60,42.71 60,44.91 59.96,44.95 59.96,46.72 v3(60.33,47.09)
  BOTTOM w0.102: v1(102.9,26.95) 103.02,26.95 103.81,27.74 103.81,30.18 105.49,31.85 v1(109.02,31.85) ; v1(57.33,20.17) 58.7,18.8 68.52,18.8 69.53,17.78 69.55,17.78 69.57,17.75 71.98,17.75 72.49,18.26 76.89,18.26 v1(77.34,18.72) ; 58.8,36.32 58.8,36.22 58.04,35.46 58.04,34.65 57.35,33.96 57.35,32.36 v2(57.78,31.93) 57.89,31.83 57.89,27.66 58.52,27.03 v1(58.52,26.54)
LPC_LAD1: length 98.4
  TOP w0.089: PCH1.AV22 60.48,46.31 v3(60.36,46.43)
  TOP w0.102: LPC_DEBUG.10 82.14,21.87 82.14,26.75 83.44,28.04 98.58,28.04 99.67,26.95 102.21,26.95 102.77,26.39 103.15,26.39 v1(103.66,26.9) ; v1(109.75,31.85) 109.39,31.49 U38.18 ; v1(59.28,27.71) 59.28,24.1 58.83,23.65 v1(58.83,20.22)
  BOTTOM w0.089: 60.02,36.32 59.89,36.45 59.89,39.73 61.8,41.63 61.8,42.42 61.32,42.9 61.32,44.4 61.02,44.7 61.02,45.77 v3(60.36,46.43)
  BOTTOM w0.102: LPC_DEBUG.10 82.45,20.37 80.57,18.49 79.07,18.49 78.1,19.46 76.76,19.46 76.05,18.75 72.31,18.75 71.83,18.26 69.7,18.26 68.68,19.28 59.77,19.28 v1(58.83,20.22) ; v1(103.66,26.9) 104.04,27.28 104.04,30.07 105.11,31.14 109.04,31.14 v1(109.75,31.85) ; v1(59.28,27.71) 59.59,28.02 59.59,29.26 58.98,29.87 58.98,30.91 59.66,31.6 59.66,34.06 60.02,34.42 60.02,36.32
LPC_LAD2: length 107.5
  TOP w0.089: PCH1.AT19 v3(59.34,47.43)
  TOP w0.102: v1(56.87,19.43) 56.77,19.53 56.77,23.14 58.12,24.49 v1(58.12,25.78) ; v1(103.38,25.96) 102.87,25.96 102.11,26.72 99.58,26.72 98.49,27.81 83.69,27.81 82.52,26.65 82.52,22.15 83.39,21.29 85.27,21.29 LPC_DEBUG.8 86.18,19.69 85.78,19.28 82.96,19.28 v1(82.88,19.35) ; U38.19 109.79,31.2 110.41,31.83 v1(110.49,31.83)
  BOTTOM w0.089: v3(59.34,47.43) 59.77,47 59.77,44.87 59.81,44.82 59.81,43.15 59.39,42.72 59.39,40.82 58.6,40.03 58.6,36.35 58.57,36.32
  BOTTOM w0.102: v1(56.87,19.43) 57.73,19.43 58.6,18.57 68.42,18.57 69.44,17.55 69.45,17.55 69.48,17.53 72.09,17.53 72.59,18.03 81.84,18.03 82.88,19.08 v1(82.88,19.35) ; v1(110.49,31.83) 110.41,31.83 109.85,31.27 109.6,31.27 109.25,30.91 105.21,30.91 104.27,29.97 104.27,26.82 103.4,25.96 v1(103.38,25.96) ; 58.57,36.32 57.81,35.56 57.81,34.75 57.1,34.04 57.1,31.37 57.66,30.81 57.66,27.56 57.91,27.31 57.91,25.98 v1(58.12,25.78)
LPC_LAD3: length 97.2
  TOP w0.089: 58.75,36.96 58.75,39.34 58.85,39.45 58.85,41.47 58.69,41.63 58.69,42.22 58.51,42.4 58.51,42.85 58.07,43.29 PCH1.BD16
  TOP w0.102: 58.75,36.96 58.75,32.11 58.32,31.67 58.32,27.89 59.05,27.15 59.05,24.33 58.06,23.34 v1(58.06,20.17) ; v1(110.34,31.06) 110.19,30.92 U38.20 ; v1(104.11,25.91) 103.68,25.48 103.02,25.48 102.01,26.49 99.42,26.49 98.32,27.58 85.62,27.58 84.38,26.34 84.38,24.71 85.47,23.62 85.47,23.62 LPC_DEBUG.7 86.18,22.12 87.07,21.23 87.07,19.56 86.39,18.87 82.63,18.87 v1(82.14,19.35)
  BOTTOM w0.102: v1(110.34,31.06) 110.26,30.99 109.68,30.99 109.35,30.66 105.28,30.66 104.5,29.87 104.5,26.29 v1(104.11,25.91) ; v1(82.14,19.35) 81.05,18.26 78.92,18.26 77.98,19.2 76.89,19.2 76.17,18.49 72.39,18.49 71.91,18.01 69.63,18.01 68.61,19.02 59.21,19.02 v1(58.06,20.17)
LPC_PIRQ_L: length 21.5
  TOP w0.089: v3(57.92,45.95) PCH1.AW17
  TOP w0.102: v1(54.33,28.8) 53.52,29.61 R671.1
  BOTTOM w0.089: v2(55.42,36.58) 55.17,36.32 ; v3(57.92,45.95) 58.36,45.51 58.36,44.52 58.48,44.39 58.61,44.27 58.61,43.7 58.31,43.4
  BOTTOM w0.102: v1(54.33,28.8) 54.41,28.8 54.86,29.26 54.86,34.42 54.94,34.49 54.94,36.09 55.17,36.32 ; v2(55.42,36.58) 55.88,36.58 57.43,38.13 57.43,40.61 58.06,41.24 58.06,43.15 58.31,43.4
LPC_PME_L: length 78.6
  TOP w0.089: 79.22,60.48 75.01,56.27 74.5,56.27 74,55.77 72.24,55.77 72.19,55.81 71.89,55.81 PCH1.W44
  TOP w0.102: v1(99.75,60.68) 98.91,61.52 87.76,61.52 R445.1 86.77,61.44 82.88,61.44 82.4,60.96 79.7,60.96 79.22,60.48 ; v1(113.46,36.27) 114.88,34.85 114.88,31.97 115.08,31.78 U38.32 115.08,29.27 115.29,29.06 115.87,29.06 117.79,27.15 R698.1 ; v1(103.71,39.57) 103.45,39.83 102.69,39.83 102.16,40.36 101.3,40.36 100.58,41.07 100.58,41.53 101.09,42.04 101.09,48.97 v1(100.79,49.28)
  BOTTOM w0.102: v1(99.75,60.68) 99.26,60.2 99.26,50.8 v2(100.15,49.91) v1(100.79,49.28) ; v1(103.71,39.57) 104.17,39.12 104.93,39.12 108.05,35.99 113.18,35.99 v1(113.46,36.27)
LPCPD_L: length 30.4
  TOP w0.089: v3(60.58,39.78) 60.58,41.12 60.2,41.5 60.2,42.15 59.54,42.81 59.54,43.06 59.45,43.14 59.45,43.62 59.2,43.87 PCH1.BC18
  TOP w0.102: R715.2 70.39,26.33 69.33,26.33 v1(68.96,26.7)
  BOTTOM w0.089: 61.49,36.32 61.49,38.86 v3(60.58,39.78)
  BOTTOM w0.102: v1(68.96,26.7) 68.66,26.39 65.38,26.39 64.52,25.53 62.48,25.53 60.55,27.45 60.55,27.94 61.44,28.83 61.44,31.39 v2(61.26,31.57) 61.44,31.75 61.44,33.3 60.93,33.81 60.93,35.46 61.49,36.02 61.49,36.32
LRST_L: length 11.1
  TOP w0.102: U38.14 106.97,31.84 106.27,31.14 106.27,29.46 105.35,28.54 C608.1 104.84,27.69 102.69,27.69 R681.2 101.64,28.73 100.63,28.73 v2(100.2,28.3)
M.2_BTWIFI_SUS_CLK: length 222
  TOP w0.102: v1(56.67,25.02) 55.07,23.42 55.07,20.8 56.18,19.69 56.18,19 56.59,18.59 56.59,15.85 v1(56.34,15.6) ; R553.2 94.13,45.75 v1(94.26,45.87) 94.13,46 R540.2 ; v1(32.69,122.02) 33.91,122.02 34.19,121.74 M2_1.50 ; v1(81.53,31.12) 82.02,30.63 87.88,30.63 91.03,33.78 v1(93.5,33.78)
  BOTTOM w0.102: v1(56.67,25.02) 57.33,24.36 60.45,24.36 60.78,24.69 65.02,24.69 65.74,25.4 69.24,25.4 69.8,25.96 78.49,25.96 81.53,29.01 v2(81.53,30.2) v1(81.53,31.12) ; v1(93.5,33.78) 93.27,34.01 93.27,37.08 94.01,37.82 94.01,45.62 v1(94.26,45.87) ; v1(56.34,15.6) 55.88,16.05 54.81,16.05 53.16,14.4 51.59,14.4 46.13,19.86 41.96,19.86 41.17,20.65 33.2,20.65 33.02,20.47 31.9,20.47 30.99,21.39 28.93,21.39 27.91,20.37 27.06,20.37 23.8,23.63 23.8,25.05 22.94,25.91 22.94,27 23.57,27.64 23.57,30.13 23.27,30.43 23.27,31.51 21.79,32.99 21.79,47.2 17.3,51.7 17.3,68.02 16.74,68.58 16.74,68.59 16.51,68.81 16.51,79.96 12.7,83.77 12.7,101.02 29.31,117.63 29.31,119.68 30.82,121.2 31.5,121.2 SC41.1 32.69,121.14 v1(32.69,122.02)
M.2_DIS_L_R: length 208.5
  TOP w0.089: v3(63.58,39.04) 63.34,39.28 63.34,42.42 63.47,42.55 63.47,42.89 63.62,43.05 63.63,43.05 63.75,43.17 PCH1.BD27
  TOP w0.102: v1(64.57,28.78) 64.57,28.09 65.51,27.15 65.51,27.13 65.56,27.08 65.56,22.35 62.13,18.92 62.13,17.96 59.97,15.8 59.97,13 59.03,12.06 56.41,12.06 53.77,9.42 53.77,8.92 53.42,8.56 52.48,8.56 52.02,9.02 50.81,9.02 50.04,8.25 43.74,8.25 38.89,13.11 33.42,13.11 33.35,13.03 33.35,13.03 33.21,12.9 28.4,8.08 28.4,8.08 28.32,8 v1(27.86,8) ; v1(12.6,28.88) 12.42,28.88 12.17,29.13 8.51,29.13 8.31,29.34 4.47,29.34 2.9,27.76 2.9,16.08 v1(2.24,15.42) ; v1(13.21,42.72) 14.6,42.72 20.35,48.46 20.35,65.23 29.08,73.96 29.08,89.33 34.14,94.39 R371.1
  BOTTOM w0.089: 63.75,36.32 63.75,38.86 v3(63.58,39.04)
  BOTTOM w0.102: v1(2.24,15.42) 2.08,15.27 2.08,9.45 3.58,7.95 9.91,7.95 10.31,8.36 27.51,8.36 v1(27.86,8) ; v1(64.57,28.78) v2(64.57,29.69) 64.57,30.78 65.28,31.5 65.28,32.77 63.7,34.35 63.7,36.27 63.75,36.32 ; v1(12.6,28.88) 13.74,30.02 13.74,34.22 12.93,35.03 12.93,42.44 v1(13.21,42.72)
M.2_RST_L_RC: length 38.8
  TOP w0.102: M2_1.52 33.69,118.54 v1(33.93,118.29) ; BT2.3 28.3,95.88 R366.1 ; R366.1 C396.1 26.8,97.69 25.45,96.34 v1(24.56,96.34) ; R366.1 28.49,97.69 R367.1
  BOTTOM w0.102: v1(24.56,96.34) 24.56,96.52 21.46,99.62 v2(21.46,102.16) 21.46,103.84 22.99,105.36 22.99,106.91 33.93,117.86 v1(33.93,118.29)
M.2_SMBCLK: length 7.9
  TOP w0.102: M2_1.60 31.69,121.71 31.14,122.25 30.2,122.25 v1(29.51,122.94)
  BOTTOM w0.102: v1(29.51,122.94) 29.51,123.53 SC37.2 29.31,123.98 28.8,124.49 28.8,125.43 v2(29.08,125.7) 29.31,125.93 SR15.2
M.2_SMBDATA: length 7.6
  TOP w0.102: M2_1.58 32.19,121.61 30.81,122.99 v1(30.25,122.99)
  BOTTOM w0.102: v1(30.25,122.99) 30.71,123.44 SC38.2 31.14,124.16 31.14,125.4 v2(30.89,125.65) 30.71,125.83 SR16.2
M.2_SSD_RST: length 4.2
  TOP w0.102: M2_2.50 107.9,17.17 108.33,16.74 v1(108.33,16.28)
  BOTTOM w0.102: v1(108.33,16.28) 108.18,16.13 SC64.1 SR35.2
M.2_SSD_SUS_CLK: length 40.7
  TOP w0.102: R539.2 93.04,46.2 v1(93.4,45.85) 93.04,45.49 R552.2 ; v1(103.61,20.37) 102.29,21.69 102.29,24.74 101.5,25.53 98.55,25.53 v1(97.69,26.39) ; v1(108.33,21.21) 107.87,21.67 M2_2.68
  BOTTOM w0.102: v1(97.69,26.39) 97.69,27.41 93.75,31.34 93.75,32.28 92.89,33.15 92.89,37.26 93.65,38.02 93.65,45.59 v1(93.4,45.85) ; v1(103.61,20.37) 103.66,20.32 v2(104.42,20.32) 106.11,20.32 SC62.1 108.08,21.46 v1(108.33,21.21)
M_BS_A0: length 45.3
  TOP w0.089: 119.74,126.26 119.74,126.87 117.62,128.99 CPU1.AY13
  TOP w0.216: DIMM2.71 105.05,96.5 105.05,98.81 105.33,99.09 105.33,99.95 118.9,113.51 118.9,121.81 arc(119.11,122.02) 119.32,121.81 119.32,119.69 arc(119.53,119.48) 119.74,119.69 119.74,126.26
M_BS_A1: length 47.6
  TOP w0.089: 120.55,126.14 120.55,127.03 118.87,128.71 118.87,129.74 119.02,129.9 119.02,130.69 CPU1.AV15
  TOP w0.216: DIMM2.190 105.84,96.75 106.81,97.71 106.81,100.3 109.84,103.34 111.03,103.34 111.95,104.26 arc(111.95,104.56) 111.65,104.56 110.88,103.79 arc(110.59,103.79) 110.59,104.08 120.55,114.05 120.55,126.14
M_BS_A2: length 46.4
  TOP w0.089: 129.69,125.25 129.69,125.96 129.06,126.59 127.79,126.59 126.39,127.99 126.39,129.83 CPU1.AW23
  TOP w0.216: 129.69,125.25 129.69,111.28 arc(129.75,111.14) 129.9,111.07 130.05,111.07 arc(130.26,110.86) 130.05,110.66 129.9,110.66 arc(129.69,110.45) 129.9,110.24 130.05,110.24 arc(130.26,110.03) 130.05,109.82 129.9,109.82 arc(129.69,109.61) 129.9,109.4 130.05,109.4 arc(130.26,109.19) 130.05,108.98 129.9,108.98 arc(129.69,108.77) 129.9,108.56 130.05,108.56 arc(130.26,108.35) 130.05,108.14 129.9,108.14 arc(129.69,107.93) 129.9,107.72 130.05,107.72 arc(130.26,107.51) 130.05,107.3 129.9,107.3 arc(129.69,107.09) 129.9,106.88 130.05,106.88 arc(130.26,106.67) 130.05,106.46 129.9,106.46 arc(129.69,106.25) 129.9,106.05 130.05,106.05 arc(130.26,105.84) 130.05,105.63 129.9,105.63 arc(129.69,105.42) 129.9,105.21 130.05,105.21 arc(130.26,105) 130.05,104.79 129.9,104.79 arc(129.69,104.58) 129.9,104.37 130.05,104.37 arc(130.26,104.16) 130.05,103.95 129.9,103.95 arc(129.75,103.89) 129.69,103.74 129.69,103.05 129.04,102.4 arc(128.74,102.4) 128.74,102.69 128.94,102.89 arc(128.94,103.19) 128.65,103.19 125.64,100.18 124.84,100.18 123.84,99.18 DIMM2.52
M_BS_B0: length 69
  TOP w0.089: v5(121.73,137.97) CPU1.AL18
  GND w0.089: 120.99,127.41 120.99,127.62 121.21,127.84 121.21,134.41 121.84,135.04 121.84,136.55 122.19,136.9 122.19,137.51 v5(121.73,137.97)
  GND w0.178: DIMM1.71 105.08,86.34 105.08,88.37 108.38,91.67 109.14,91.67 109.63,92.15 109.63,93.09 110.59,94.06 110.59,94.87 111.61,95.88 111.61,96.6 110.59,97.61 110.59,98.9 111.84,100.15 111.84,104.24 arc(112.06,104.47) 112.29,104.24 112.29,101.12 arc(112.52,100.89) 112.75,101.12 112.75,106.86 112.12,107.49 112.12,108.81 120.99,117.68 120.99,127.41
M_BS_B1: length 69.6
  TOP w0.089: v5(122.64,137.06) CPU1.AM18
  GND w0.089: 122.02,127.46 122.02,127.53 122.48,127.99 122.48,129.54 122.61,129.67 122.61,134.42 122.17,134.85 122.17,136.45 122.64,136.93 v5(122.64,137.06)
  GND w0.178: 122.02,127.46 122.02,123.86 arc(122.07,123.74) 122.19,123.69 arc(122.3,123.64) 122.35,123.53 122.35,123.33 arc(122.3,123.21) 122.19,123.17 arc(122.07,123.12) 122.02,123 122.02,122.8 arc(122.07,122.69) 122.19,122.64 arc(122.3,122.59) 122.35,122.47 122.35,122.28 arc(122.3,122.16) 122.19,122.11 arc(122.07,122.06) 122.02,121.95 122.02,121.75 arc(122.07,121.63) 122.19,121.58 arc(122.3,121.54) 122.35,121.42 122.35,121.22 arc(122.3,121.11) 122.19,121.06 arc(122.07,121.01) 122.02,120.89 122.02,117.3 117.97,113.24 117.97,110.02 117.05,109.11 arc(116.68,109.11) 116.68,109.48 117.38,110.18 arc(117.38,110.56) 117.01,110.56 113.69,107.24 113.69,106.91 arc(113.77,106.72) 113.95,106.64 113.99,106.64 arc(114.25,106.38) 113.99,106.12 113.95,106.12 arc(113.69,105.85) 113.95,105.59 113.99,105.59 arc(114.25,105.33) 113.99,105.06 113.95,105.06 arc(113.69,104.8) 113.95,104.53 113.99,104.53 arc(114.25,104.27) 113.99,104.01 113.95,104.01 arc(113.77,103.93) 113.69,103.74 113.69,100.03 112.58,98.92 112.58,97.59 113.58,96.59 113.58,95.98 112.58,94.98 112.58,94.08 111.58,93.07 111.58,91.92 110.08,90.42 108.88,90.42 107.04,88.58 107.04,87.63 105.84,86.43 DIMM1.190
M_BS_B2: length 62.4
  TOP w0.089: v3(130.84,129.74) 131.29,130.2 CPU1.AW28
  GND w0.089: 131.34,126.31 131.34,127.38 131.39,127.43 131.39,128.09 130.96,128.52 130.96,129.62 v3(130.84,129.74)
  GND w0.178: DIMM1.52 123.84,88.55 125.21,89.92 126.21,89.92 130.6,94.31 130.6,96.25 129.46,97.39 129.46,100.01 arc(129.21,100.25) 128.97,100.01 128.97,97.04 arc(128.73,96.8) 128.49,97.04 128.49,103.17 130.3,104.98 130.3,114.8 132.31,116.81 132.31,122.96 arc(132.08,123.19) 131.85,122.96 131.85,120.29 arc(131.62,120.07) 131.39,120.29 131.39,123.49 131.34,123.55 131.34,126.31
M_CAS_A_L: length 43.1
  TOP w0.089: 116.56,126.8 116.56,127.15 115.79,127.93 CPU1.AY11
  TOP w0.216: 116.56,126.8 116.56,113.82 arc(116.35,113.61) 116.14,113.82 116.14,116.15 arc(115.93,116.36) 115.72,116.15 115.72,112.73 102.08,99.09 102.08,98.43 DIMM2.74
