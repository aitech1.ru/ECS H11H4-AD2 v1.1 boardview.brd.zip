# Allegro board ECS H11H4-AD2 v1.1 boardview.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
P95V_PWRGD: length 2.7
  TOP w0.254: U35.1 126.47,52.07 125.96,51.56 C535.2 R512.2
VCCIO_EN: length 234.6
  TOP w0.102: R339.2 59.38,119.19 R341.1 57.2,118.24 v1(57.02,118.41) ; v1(54.86,116.43) 54.86,115.93 56.9,113.89 56.9,106.73 52.65,102.49 51.13,102.49 50.27,101.63 48.72,101.63 46.35,99.26 46.35,94.54 47.6,93.29 47.6,90.09 53.62,84.07 53.62,80.58 56.19,78 60.5,78 61.16,78.66 74.52,78.66 75.01,78.18 75.64,78.18 v1(76.12,78.66) ; R689.2 160.68,27.01 v1(160.68,20.62) ; v1(100.99,50.09) 101.35,49.73 101.35,41.55 v1(101.07,41.28) ; v1(147.04,20.6) R686.2
  TOP w0.203: C367.2 60.22,121.37 60.22,122.96 60.35,123.09 60.35,123.55 60.59,123.78 U28.13
  TOP w0.254: R339.2 C367.2
  BOTTOM w0.102: v1(100.99,50.09) 99.52,51.56 99.52,59.49 104.42,64.39 104.42,77.17 102.64,78.94 94.26,78.94 93.52,79.68 77.14,79.68 v1(76.12,78.66) ; v1(57.02,118.41) 57.02,117.83 55.63,116.43 v1(54.86,116.43) ; v1(160.68,20.62) 160.63,20.68 v2(159.69,20.68) 159.46,20.45 147.19,20.45 v1(147.04,20.6) 146.89,20.45 138.91,20.45 131.14,28.22 129.67,28.22 122.83,35.05 121.06,35.05 120.04,34.04 118.49,34.04 116.99,35.53 107.77,35.53 104.65,38.66 101.98,38.66 101.17,39.47 101.17,41.17 v1(101.07,41.28)
VCCIO_PWRGD: length 7.8
  TOP w0.102: v2(70.05,123.67) R325.2
  TOP w0.203: R325.2 R324.1 67.81,123.72 66.27,123.72 R323.1 C355.2 64.97,124.33 64.42,123.78 U28.4
VCCIO_SENSE: length 72.5
  TOP w0.089: v1(55.55,121.46) 55.75,121.67 R331.2 ; v1(73.38,136.12) 73,136.5 73,138.53 71.53,140 67.39,140 63.64,136.26 v1(63.64,135.85)
  TOP w0.102: v1(86.08,137.8) 86.49,138.2 87.25,138.2 93.32,144.27 101.46,144.27 103.34,142.39 104.11,142.39 104.15,142.43 106.62,142.43 107.19,143 CPU1.AF4
  BOTTOM w0.089: v1(86.08,137.8) 85.57,137.29 85.12,137.29 84.3,138.1 76.76,138.1 74.78,136.12 v1(73.38,136.12) ; v1(63.64,135.85) 62.73,135.85 59.87,132.99 59.87,130.68 56.92,127.74 56.92,124.51 55.55,123.14 v2(55.55,122.45) v1(55.55,121.46)
VCCST_ON: length 2.7
  TOP w0.102: R297.2 C309.1 70.43,147.32 U26.3
VCCST_PWRGD: length 259.4
  TOP w0.102: v1(32.97,123.6) 33.22,123.6 34.42,124.79 34.42,125.76 35.1,126.44 40.31,126.44 50.14,136.27 55.65,136.27 56.34,136.96 60.91,136.96 67.97,144.02 67.97,151.69 70.84,154.56 R283.1 ; v1(29.51,24.59) 29.51,23.98 27.58,22.05 v1(27.58,21.82) ; v1(48.74,24.26) 49.12,24.64 49.12,25.37 R714.2 ; R314.2 6.78,126.52 6.02,127.28 6.02,127.86 v1(3.91,129.97) ; v1(3.12,95.55) 13.54,85.14 v1(14.12,85.14)
  BOTTOM w0.102: v1(27.58,21.82) 26.92,21.82 24.74,24 24.74,30.66 24.36,31.04 24.36,31.98 23.06,33.27 23.06,47.49 18.64,51.91 18.64,51.92 18.49,52.07 18.49,68.48 17.6,69.37 17.6,80.72 14.12,84.2 v1(14.12,85.14) 13.92,85.34 13.92,100.23 17.93,104.24 19.35,104.24 21.21,106.1 21.21,107.31 31.93,118.03 31.93,119.02 33.65,120.75 33.65,122.68 32.97,123.37 v1(32.97,123.6) ; v1(3.12,95.55) 2.72,95.96 2.72,128.78 v1(3.91,129.97) ; v1(29.51,24.59) 29.72,24.38 31.45,24.38 32.31,25.25 v2(34.09,25.25) 34.42,24.92 39.07,24.92 41.05,22.94 43.46,22.94 43.56,23.04 47.88,23.04 48.74,23.9 v1(48.74,24.26)
VCCST_PWRGD_CPU: length 35.1
  TOP w0.089: 100.63,153.31 97.38,153.31
  TOP w0.102: R282.1 R283.2 74.62,153.92 82.32,153.92 83.74,155.35 91.14,155.35 93.17,153.31 97.38,153.31 ; 100.63,153.31 102.31,151.64 104.6,151.64 105,151.23 CPU1.U2
VCCST_SS: length 2.1
  TOP w0.102: C318.1 73.05,146.37 73.05,147.17 72.9,147.32 U26.6
VDDQ_PWRGD: length 74.8
  TOP w0.102: v1(156.67,74.8) 156.59,74.88 152.12,74.88 150.67,76.33 149.36,76.33 R398.2 ; v1(152.68,42.09) 153.14,41.63 R688.1 152.65,27.93 152.65,26.75 153.22,26.18 QN31.1
  TOP w0.203: U31.8 147.15,74.68 147.37,74.9 147.37,75.61 R398.2
  BOTTOM w0.102: v1(152.68,42.09) 150.57,42.09 149.53,43.13 149.53,48.31 155.98,54.76 157.07,54.76 163.58,61.26 163.58,65.1 159.11,69.57 159.11,72.29 v2(158.19,73.2) 156.67,74.73 v1(156.67,74.8)
VSS_SA_IO_SENSE: length 41.7
  TOP w0.102: CPU1.AE4 106.73,143.46 106.73,142.85 106.52,142.64 104.07,142.64 104.04,142.61 103.44,142.61 101.55,144.5 93.19,144.5 87.12,138.43 85.95,138.43 v1(85.34,137.82) ; v1(73.74,137.13) 73.74,139.95 R300.1
  BOTTOM w0.102: v1(85.34,137.82) 84.81,138.35 76.68,138.35 75.46,137.13 v1(73.74,137.13)
24M_IN_R: length 9.6
  BOTTOM w0.102: SY1.3 35.83,65.51 37.53,65.51 SC43.1 39.11,65.02 SR17.1 39.72,64.47 SR36.1
662_P3: length 2.7
  TOP w0.102: C132.1 16.39,211.18 CODEC.3
662_P4: length 2.5
  TOP w0.102: CODEC.4 16.89,211.66 R151.1
662_P9: length 7.5
  TOP w0.102: CODEC.9 19.39,212.49 20.27,211.61 20.62,211.61 C130.1 20.65,210.51 20.65,207.62 RJ1.2
662_P11: length 6.8
  TOP w0.102: CODEC.11 20.39,212.35 20.62,212.12 21.87,212.12 22.33,211.66 C131.1 21.89,210.61 21.89,208.68 R168.1
95858_VDD: length 43.9
  TOP w0.203: U19.24 163.47,214.58 162.66,215.39 C92.2
  TOP w0.381: v1(172.19,206.12) 171.93,206.12 170.92,207.14 R173.2 ; v1(180.04,209.88) 180.06,209.91 180.06,215.2 179.2,216.06 R112.2 179,216.61 v1(174.62,216.61)
  TOP w0.508: R100.1 v1(160.88,217.68) 162.63,215.93 C92.2
  BOTTOM w0.381: v1(180.04,209.88) 178.44,208.28 178.03,208.28 176.99,207.24 v2(176.48,207.24) 174.7,207.24 173.58,206.12 v1(172.19,206.12)
  BOTTOM w0.508: v1(160.88,217.68) 161.57,218.36 162.79,218.36 164.54,216.61 v2(172.14,216.61) v1(174.62,216.61)
+ATX_3VSB: length 629.6
  TOP w0.152: v4(57.56,54.91) 57.76,55.12 PCH1.W15
  TOP w0.178: U38.12 106.78,32.64 106.5,32.36 106.5,32.26 105.61,31.37 105.61,31.32
  TOP w0.203: PCH1.BA24 62.23,44.78 v3(61.85,45.16)
  TOP w0.254: C522.1 v1(152.76,54.61) ; R433.1 192.63,64.04 192.63,61.81 191.79,60.96 189.48,60.96 183.62,66.83 183.62,71.37 182.5,72.49 174.57,72.49 170.97,68.88 v1(170.97,53.64) ; v1(42.9,25.58) 42.9,27.36 v1(42.52,27.74) 42.72,27.94 R685.2 ; R523.2 141.58,50.9 v1(141.2,51.28) ; v1(169.24,53.64) 166.57,53.64 EC33.1 ; v1(34.29,49.28) 33.71,49.28 32.59,48.16 32.59,44.63 31.67,43.71 31.67,33.48 v1(30.84,32.64) ; v1(50.11,28.88) 50.11,28.38 R682.2 ; R606.2 54.58,35.03 55.12,34.49 55.12,33.84 R624.2 R623.2 ; v1(102.9,32.97) 102.59,33.27 R637.2
  TOP w0.305: v1(105.41,30.02) 105.41,30.7 C600.1 105.56,30.97 105.56,31.27 105.61,31.32
  TOP w0.381: v1(111.53,24.69) 111.53,25.53 R701.2 ; R694.2 121.54,26.87 v1(121.44,26.77) ; C600.1 104.77,31.34 103.78,31.34 v1(103.68,31.24)
  TOP w0.406: v1(40.21,25.4) 40.06,25.25 40.06,20.22 39.65,19.81 39.65,18.87 v1(39.57,18.8)
  TOP w0.508: v1(22.05,75.51) 22.05,75.84 23.11,76.91 23.11,79.22 18.69,83.64 16.81,83.64 4.65,95.81 4.65,102.74 3.48,103.91 v1(3.48,106.12) ; v6(7.01,188.29) 7.01,188.62 11.53,193.14 11.53,198.96 13.92,201.35 19.23,201.35 20.93,203.05 41.76,203.05 44.42,200.38 44.42,191.52 47.78,188.16 47.78,187.17 49.06,185.89 49.67,185.89 50.52,185.04 C233.1 51.64,184.42 RJ2.3 ; R623.2 v1(53.44,32.54) ; v1(63.7,28.65) 63.7,28.32 65.13,26.9 65.13,22.53 61.7,19.1 61.7,18.16 59.54,16 59.54,13.44 v1(59.46,13.36) 58.6,12.5 56.21,12.5 53.11,9.4 v1(53.11,9.3) ; v1(3.71,183.36) 3.23,182.88 3.23,151.1 2.72,150.6 2.72,143.38 3.61,142.49 ME_TEST.1 ; ME_TEST.1 v1(6.58,143.76) ; ME_TEST.1 6.73,141.07 v1(6.73,139.01) ; R572.2 104.19,42.24 105.11,43.15 v1(105.11,43.92) 105.77,43.92 106.52,44.67 R557.2 R558.2 R559.2 110.12,44.96 v1(111.79,44.96) ; v1(8.84,109.37) 9.75,108.46 9.75,105.31 8.9,104.45 R360.2 ; R697.2 117.22,25.97 117.22,25.32 v1(117.4,25.15) ; v1(7.44,145.03) R294.1 ; v1(105.41,25.91) 105.35,25.97 R696.2 ; R616.2 v1(102.18,36.49) 102.18,36.54 101.19,37.53 R594.1 100.56,37.15 100.56,36.61 v1(100.53,36.58) ; v1(121.44,28.88) 121.44,30.07 121.31,30.2 R665.2 R646.2 R640.2 R636.2 ; R699.2 108.33,25.46 v1(108.33,24.89)
  BOTTOM w0.254: v1(30.84,32.64) 31.65,31.83 31.65,30.66 29.64,28.65 29.64,26.08 29.99,25.73 31.83,25.73 34.24,28.14 39.24,28.14 39.78,27.61 42.39,27.61 v1(42.52,27.74) ; v1(170.97,53.64) v1(169.24,53.64) ; 63.45,34.06 63.45,34.17 63.4,34.22 63.4,36.4 63.45,36.45 63.45,38.43 62.99,38.89 62.99,39.4 62.08,40.31 62.08,42.55 61.65,42.98 61.65,44.96 v3(61.85,45.16)
  BOTTOM w0.305: v1(40.21,25.4) 40.49,25.68 42.77,25.68 42.9,25.55 ; 42.9,25.55 43.23,25.22 44.95,25.22 45.54,25.81 46.69,25.81 49.76,28.88 v1(50.11,28.88) 50.42,29.18 51.64,29.18 52.41,29.96 52.62,29.96 53.44,30.78 v1(53.44,32.54) ; 42.9,25.55 v1(42.9,25.58)
  BOTTOM w0.381: v1(63.7,28.65) 63.7,30.71 64.87,31.88 64.87,32.64 63.45,34.06
  BOTTOM w0.508: v1(7.44,145.03) 7.44,144.63 v1(6.58,143.76) ; v1(103.68,31.24) 102.9,32.03 v1(102.9,32.97) 102.18,33.69 v1(102.18,36.49) ; 3.51,106.15 3.51,107.14 4.24,107.87 4.24,128.4 7.87,132.03 7.87,135.43 6.73,136.58 v1(6.73,139.01) ; 3.51,106.15 v1(3.48,106.12) ; 3.51,106.15 5.64,106.15 8.84,109.35 v1(8.84,109.37) ; v1(39.57,18.8) 40,18.8 40.82,17.98 41.63,17.98 42.11,17.5 44.75,17.5 52.96,9.3 v1(53.11,9.3) ; v6(7.01,188.29) 7.01,186.66 v1(3.71,183.36) ; v1(22.05,75.51) 22.05,70.66 22.68,70.03 22.68,53.87 26.16,50.39 29.54,50.39 ; v1(155.4,57.07) 154.43,57.07 152.76,55.4 v1(152.76,54.61) 152.3,54.61 148.36,50.67 141.81,50.67 v1(141.2,51.28) 140.41,52.07 137.31,52.07 135.75,50.51 135.06,50.51 130.76,46.2 121.41,46.2 120.12,44.91 111.84,44.91 v1(111.79,44.96) ; v1(59.46,13.36) 72.77,13.36 75.67,10.46 76.86,10.46 77.6,9.73 89.92,9.73 91.29,8.36 97.92,8.36 101.83,12.27 101.83,20.8 103.35,22.33 104.8,22.33 106.1,23.62 106.1,24.84 105.41,25.53 v1(105.41,25.91) 105.59,26.09 107.37,26.09 ; 107.37,26.09 108.33,25.12 v1(108.33,24.89) 108.89,24.33 111.18,24.33 v1(111.53,24.69) 112.62,23.6 116.18,23.6 117.4,24.82 v1(117.4,25.15) 117.98,24.56 119.43,24.56 121.44,26.57 v1(121.44,26.77) v1(121.44,28.88) ; 107.37,26.09 107.37,28.98 106.32,30.02 v1(105.41,30.02) ; v1(105.11,43.92) 102.39,43.92 99.92,41.45 99.92,37.19 v1(100.53,36.58)
+ATX_3VSB_FB: length 5.2
  TOP w0.102: R475.2 v1(156.36,55.47)
  TOP w0.254: U36.7 158.34,54.32 C524.2 R468.2 157.23,55.63 R475.2
+ATX_5VSB: length 544.6
  TOP w0.254: R639.1 91.16,32.72 90.02,31.57 90.02,30.71 89.03,29.72 79.86,29.72 78.1,27.97 78.1,25.76 79.55,24.31 79.55,22.3 79.12,21.87 77.34,21.87 76.85,21.37 75.55,21.37 75.01,20.83 75.01,19.48 77.44,17.04 78.16,17.04 v1(78.71,16.48) ; 76.56,2.03 76.56,6.3 74.68,8.18 74.68,12.12 75.26,12.7 75.26,13.54 75.51,13.79 76.94,13.79 77.62,13.11 79.1,13.11 v1(79.32,13.34) ; D23.2 14.87,7.93 14.43,7.49 v1(14.43,3.4)
  TOP w0.508: v1(137.67,43.68) 137.37,43.99 R555.2 ; v1(150.44,11.63) 150.44,30.05 148.84,31.65 ; R663.1 90.25,30.48 90.02,30.71 ; v1(2.54,151.76) 2.54,186.36 9.78,193.6 9.78,199.31 v1(10.79,200.33) ; v1(26.92,206.55) 27.65,207.28 D12.N 29.18,207.8 L9.1 ; 120.55,20.24 120.55,22.63 123.26,25.34 R710.2 ; 120.55,20.24 v1(125.12,20.24) ; 120.55,20.24 119.81,19.51 119.81,1.98 118.92,1.09 77.5,1.09 76.56,2.03 56.34,2.03 53.12,5.25 52.06,5.25 50.36,6.95 42.58,6.95 41.3,8.23 41.3,8.84 38.4,11.73 33.88,11.73 29.69,7.54 29.69,3.53 27.25,1.09 v1(18.44,1.09) ; v1(144.22,43.56) 144.96,42.82 146.43,42.82 ; 146.43,42.82 147.19,42.82 ; 146.43,42.82 147.17,43.56
  TOP w1.016: ATX_POWER.9 142.56,34.9 C595.1 R649.2 143.93,30.35 144.56,29.72 146.91,29.72 148.84,31.65
  TOP w1.27: 148.84,31.65 148.84,41.88 147.55,43.18
  BOTTOM w0.254: v1(79.32,13.34) 78.74,13.34 77.42,14.66 77.42,15.85 78.05,16.48 v1(78.71,16.48)
  BOTTOM w0.508: v1(18.44,1.09) 16.74,1.09 v1(14.43,3.4) 12.83,1.8 3.68,1.8 0.76,4.72 0.76,140.51 2.54,142.29 v1(2.54,151.76) 3.73,152.96 v1(8.66,152.96) ; v1(150.44,11.63) 149.3,10.49 142.39,10.49 132.64,20.24 v1(125.12,20.24) ; v1(10.79,200.33) 13.06,202.59 15.8,202.59 v2(17.27,204.06) 17.98,204.77 25.15,204.77 v1(26.92,206.55) ; v1(137.67,43.68) 137.79,43.56 v1(144.22,43.56)
+DDR_VTT: length 20.3
  TOP w0.203: 145.82,69.95 145.37,70.4 U31.20 ; U31.18 144.57,69.73
  TOP w0.635: C390.1 56.98,100.52 57.18,100.33 v1(57.63,100.33) ; C415.1 54.19,89.64 DIMM1.120
  BOTTOM w0.635: DIMM2.120 55.84,98.54 v1(57.63,100.33)
  BOTTOM w1.016: DIMM2.120 55.84,97.24 55.58,96.98 55.58,94.65 DIMM2.240 55.63,94.17 55.63,88.21 DIMM1.120
  vias: v1(95.05,80.62) v1(95.76,79.93) v1(147.32,69.01) v1(147.73,69.8) v1(148.31,69.06) v2(115.06,75.34)
+DRIVER_POWER: length 255.3
  TOP w0.508: v1(154.41,206.88) 154.41,207.39 R167.2 ; R261.2 v1(187.3,181.61) ; R229.2 92.71,193.78 91.8,194.69 91.8,197.92 v1(91.67,198.04) ; 197.59,129.95 198.22,130.58 198.22,137.72 v1(196.77,139.17) 198.27,140.67 198.27,189.64 197.46,190.45 197.46,201.8 196.44,202.82 183.69,202.82 181.35,200.48 180.14,200.48 176.5,196.85 v1(175.87,196.85) 175.42,197.3 173.26,197.3 173.09,197.13 162.26,197.13 161.52,197.87 154.03,197.87 153.39,198.5 153.39,203.78 v1(151.38,205.79) 146.23,210.95 129.26,210.95 127.74,212.47 123.6,212.47 121.45,210.32 112.84,210.32 111.51,208.99 110.16,208.99 109.45,208.28 103,208.28 100.81,206.1 v1(100.81,204.22) ; v1(187.43,144.27) 188.06,144.91 188.7,144.91
  BOTTOM w0.508: v1(175.87,196.85) 175.87,196.6 174.93,195.66 173.56,195.66 172.77,194.87 172.77,185.72 175.31,183.18 185.72,183.18 v1(187.3,181.61) ; v1(187.43,144.27) 189.46,144.27 191.24,142.49 191.24,140.08 191.82,139.5 196.44,139.5 v1(196.77,139.17) ; v1(91.67,198.04) 93.45,199.82 v2(93.45,200.66) 93.45,201.85 95.81,204.22 v1(100.81,204.22) ; v1(151.38,205.79) 151.74,206.15 153.67,206.15 v1(154.41,206.88)
+DVI_VGA_VCC: length 31.6
  TOP w0.305: 163.7,231.5 v1(165.25,231.5) ; R16.1 R12.1
  TOP w0.381: R12.1 188.37,234.16 187.43,235.1 v1(187.02,235.1)
  BOTTOM w0.254: v1(165.25,231.5) 165.25,232.05 168.27,235.08 174.45,235.08 175.13,235.76 186.36,235.76 v1(187.02,235.1)
  BOTTOM w0.305: v1(187.02,235.1) 186.99,235.1 186.54,234.65 186.54,233.68 186.87,233.34 SR2.2
  vias: v1(161.49,231.65)
+LAN_3VSB_FB: length 6.7
  TOP w0.102: R279.2 4.22,164.06 v2(4.22,164.82)
  TOP w0.254: U25.7 5.44,159.72 C269.2 4.8,161.96 ; 4.8,161.96 4.8,163.48 R279.2 ; 4.8,161.96 R280.2
+LDOVDD: length 50.5
  TOP w0.254: CODEC.29 18.89,223.28 18.54,223.62
  TOP w0.508: v1(15.34,226.44) 15.6,226.44 C23.1 16.71,225.33 C25.1 18.01,224.16 18.54,223.62 ; v1(34.81,222.62) 26.97,230.45 20.4,230.45 v1(19.46,229.51) ; v1(30.61,209.98) 30.38,209.75 L9.2
  BOTTOM w0.508: v1(15.34,226.44) 16.21,227.3 16.21,228.52 17.2,229.51 v1(19.46,229.51) ; v1(34.81,222.62) 35.86,221.56 v2(35.86,217.04) 35.86,212.12 33.73,209.98 v1(30.61,209.98)
+R_VDD10: length 40.6
  TOP w0.203: U21.22 52.37,198.59 51.32,197.55 51.32,197.37 ; U21.3 52.37,204.15 52.35,204.17 ; U21.30 54.81,202.13 55.19,202.51 ; 50.09,203.99 50.37,203.72 U21.8
  TOP w0.254: 50.09,203.99 48.82,205.26 C155.2 ; C156.2 52.35,204.68 52.35,204.17
  TOP w0.508: v1(52.04,196.32) 51.4,196.32 C207.1 51.32,196.4 51.32,197.37 ; C155.2 48.62,204.67 v1(48.79,204.5) ; v1(53.64,205.44) 53.47,205.26 C156.2 ; v1(55.91,201.53) 56.14,201.76 C177.2 55.94,202.51 55.19,202.51
  BOTTOM w0.508: v1(48.79,204.5) 52.7,204.5 v1(53.64,205.44) 56.03,205.44 56.69,204.77 56.69,203.73 55.91,202.95 v1(55.91,201.53) v2(55.91,200.07) 55.91,194.68 v1(56.72,193.88) ; v1(55.73,193.6) 55.45,193.32 53.11,193.32 52.04,194.39 v1(52.04,196.32)
+R_VDD33: length 101.9
  TOP w0.102: 55.47,188.85 54.81,189.51 54.81,192.3 R234.1
  TOP w0.203: 54.84,203.45 54.32,202.93 U21.32 ; 48.44,202.06 48.51,202.13 U21.11
  TOP w0.406: v1(68.73,215.21) C120.2 ; U18.5 v1(70.92,215.21) ; U17.5 v1(75.29,215.21) ; R133.2 v1(66.42,215.39) ; C117.2 73.1,214.93 v1(73.38,215.21)
  TOP w0.508: 48.44,202.06 C179.1 46.93,202.32 45.49,203.76 v1(45.49,204.42) 45.49,210.92 v1(49.35,214.78) ; 54.84,203.45 54.97,203.58 C172.1 56.14,204.08 v1(55.78,204.44) ; R133.2 R132.2 ; v1(50.34,194.56) 50.34,195.36 R224.1 ; USB2_LAN.14 83.67,218.76 C97.2 83.56,215 D7.N v1(82.52,215.93)
  BOTTOM w0.254: v1(82.52,215.93) 76,215.93 v1(75.29,215.21)
  BOTTOM w0.406: v1(49.35,214.78) 49.58,215.01 61.8,215.01 62.66,215.87 65.94,215.87 v1(66.42,215.39) 67.06,214.76 68.28,214.76 v1(68.73,215.21) v1(70.92,215.21) v1(73.38,215.21) v1(75.29,215.21)
  BOTTOM w0.508: 53.9,203.1 53.44,203.56 46.35,203.56 v1(45.49,204.42) ; 53.9,203.1 55.24,204.44 v1(55.78,204.44) ; 53.9,203.1 53.9,199.26 50.34,195.71 v1(50.34,194.56) 50.34,193.52 52.12,191.74 v1(53.92,191.74)
+R_VDDREG:
  vias: v2(52.68,193.95)
+RTCVCC: length 288.7
  TOP w0.203: v3(60.43,45.01) 60.65,44.78 PCH1.BA22
  TOP w0.254: v1(54.08,18.59) 54.08,14.96 53.39,14.27 52.63,14.27 51.59,13.23 v1(51.59,12.6) ; v1(121.77,7.95) 122.12,7.95 125.37,4.7 129.34,4.7 130.35,3.68 179.63,3.68 198.17,22.22 198.17,55.09 196.77,56.49 196.77,66.63 194.28,69.12 D17.3 192.25,70.74 191.49,71.5 186.16,71.5 CLR_CMOS.1 ; v1(103.96,10.08) 106.1,7.95 110.16,7.95 110.57,8.36 112.29,8.36 v1(112.7,7.95)
  TOP w0.305: R605.1 R604.1
  TOP w0.381: v1(56.24,26.54) 56.18,26.54 54.15,24.51 50.04,24.51 v1(49.96,24.59) 49.73,24.82 49.73,25.61 48.67,26.67 47.47,26.67 46.53,27.61 v1(45.9,27.61)
  TOP w0.406: v1(51.54,34.54) 51.46,34.62 51.46,35.51 51.92,35.97 R604.1
  BOTTOM w0.152: 60.55,43.23 60.88,43.56 60.88,44.22 60.43,44.68 v3(60.43,45.01)
  BOTTOM w0.254: v1(51.59,12.6) 51.79,12.6 54.58,9.8 55.45,9.8 57.2,8.05 71.12,8.05 71.91,8.84 74.29,8.84 75.03,8.1 81.51,8.1 82.93,6.68 98.93,6.68 101.96,9.7 103.58,9.7 v1(103.96,10.08) ; v1(54.08,18.59) 53.14,18.59 51.66,20.07 51.66,21.59 49.96,23.29 v1(49.96,24.59) ; v1(112.7,7.95) v1(121.77,7.95)
  BOTTOM w0.381: 60.55,43.23 60.55,41.63 59.94,41.02 59.94,40.61 59.23,39.9 59.23,39.62 ; v1(56.24,26.54) 56.31,26.54 57.86,24.99 58.66,24.99 SC59.1 59.18,25.51 59.18,26.9 58.27,27.81 58.27,31.09 58.95,31.77 SC56.1
  BOTTOM w0.406: v1(45.9,27.61) 46.13,27.61 50.5,31.98 51.21,31.98 51.54,32.31 v1(51.54,34.54)
  BOTTOM w0.508: 59.23,39.62 59.23,36.02 58.52,35.31 58.52,34.33 SC56.1
+SPI_3P3V: length 49.2
  TOP w0.508: SPIROM1.8 58.78,5.97 57.94,5.13 C643.1 56.99,4.62 56.67,4.29 55.14,4.29 54.08,5.36 C641.1 54.08,7.14 54.58,7.65 ; 54.58,7.65 55.24,8.31 55.24,9.86 v1(56.13,10.74) 56.79,11.4 59.69,11.4 60.66,12.37 60.66,15.52 62.49,17.36 SPI_DEBUG.4 ; 54.58,7.65 54.97,7.26 R759.1 ; D22.3 71.26,13.94 R740.1 71.22,12.48 ; 71.22,12.48 71.22,12.45 71.2,12.42 71.2,12.37 v1(72.01,11.56) ; 71.22,12.48 R748.1
  BOTTOM w0.508: v1(56.13,10.74) 57.43,9.45 58.72,9.45 v2(60.35,11.07) 60.6,11.33 64.77,11.33 65.25,10.85 67.49,10.85 68.28,11.63 71.93,11.63 v1(72.01,11.56)
+USB3VCC2_2: length 242.8
  TOP w0.102: 4.55,48.23 2.59,46.28 2.59,16.64 v1(2.21,16.26) ; R582.1 126.11,41.02 128.5,38.63 128.5,37.52 129.54,36.47 131.01,36.47 131.52,35.97 131.52,33.27 131.14,32.89 130.12,32.89 127.51,30.28 127.51,25.25 129.54,23.22 129.54,13.67 v1(128.5,12.62)
  TOP w0.406: C590.1 14.57,33.81 14.1,34.29 v1(12.95,34.29) ; USB3F1.1 9.39,50.02 10.64,48.77 10.64,44.75 11.68,43.71 v1(12.67,43.71) ; U39.5 v1(12.95,31.34)
  BOTTOM w0.102: v1(128.5,12.62) 127.43,11.56 127.43,6.02 123.9,2.49 120.04,2.49 119.33,3.2 117.42,3.2 115.44,1.22 46.63,1.22 42.9,4.95 42.9,7.06 38.35,11.61 33.96,11.61 31.01,8.66 10.13,8.66 9.73,8.25 3.94,8.25 2.79,9.4 2.79,15.67 v1(2.21,16.26)
  BOTTOM w0.406: v1(12.95,31.34) 13.33,31.72 13.33,33.91 v1(12.95,34.29) 12.47,34.77 12.47,43.51 v1(12.67,43.71)
+USB3VCC_C1: length 20.5
  TOP w0.406: C36.1 v1(88.75,225.3) ; v1(90.9,225.76) 90.88,225.74 U14.5
  BOTTOM w0.406: v1(90.9,225.76) 89.2,225.76 v1(88.75,225.3)
  BOTTOM w0.508: v1(105.94,225.7) 102.29,225.7 101.37,226.62 91.76,226.62 v1(90.9,225.76)
+USBVCC0: length 22.2
  TOP w0.406: U16.5 61.57,210.82 v1(61.24,210.49)
  BOTTOM w0.254: v1(80.16,211.2) 79.88,210.92 77.32,210.92 76.99,211.25 65.56,211.25 64.74,212.06 62.26,212.06 SC15.1 61.24,211.04 v1(61.24,210.49)
+USBVCC1: length 22.1
  TOP w0.406: 4.67,25.27 4.01,25.27 3.28,24.54 3.28,16.99 3.96,16.31 8.1,16.31 8.92,15.49 v1(11.13,15.49) C629.1 ; U42.5 v1(11.23,17.65)
  BOTTOM w0.381: v1(11.23,17.65) 11,17.42 11,15.62 v1(11.13,15.49)
+USBVCC2: length 9.8
  TOP w0.508: v1(12.67,69.18) 12.12,69.74 C468.1 11.51,69.74 11.4,69.85 U32.5
  BOTTOM w0.254: v1(12.67,69.18) 12.65,69.21 12.65,76.43 v1(12.75,76.53)
+V_3P3_LAN: length 108.9
  TOP w0.508: R279.1 5.4,162.31 C269.1 6.23,162.27 C267.1 ; RJ2.1 v1(56.62,185.55)
  TOP w0.762: v1(44.32,203.89) 43.46,204.75 24.23,204.75 v1(23.22,205.77) ; R279.1 5.26,163.98 v1(5.26,187.2)
  BOTTOM w0.508: v1(44.32,203.89) 44.98,203.89 46.05,202.82 48.54,202.82 50.01,201.35 50.01,196.39 49.45,195.83 49.45,193.24 56.62,186.08 v1(56.62,185.55)
  BOTTOM w0.762: v1(5.26,187.2) 5.26,188.59 8.76,192.1 8.76,194.54 9.78,195.55 9.78,204.22 v2(11.2,205.64) 23.09,205.64 v1(23.22,205.77)
+VCORE: length 420.2
  TOP w0.203: SP4.1 143.36,187.03 L14.2 ; SP3.1 125.83,187.03 L13.2 ; SP5.1 177.01,169.23 L16.2
  TOP w0.254: 188.29,205.79 188.29,220.24 187.36,221.17 178.19,221.17 175.51,223.85 175.51,224.64 174.35,225.81 167.46,225.81 R37.2 ; 188.29,205.79 188.93,205.79 190.37,204.34 197.1,204.34 198.68,202.77 198.68,191.08 199.36,190.4 199.36,93.27 187.68,81.58 187.68,74.04 v1(189.59,72.14) ; 188.29,205.79 186.74,204.24 183.49,204.24 180.9,201.65 179.72,201.65 176.55,198.48 169.04,198.48 v1(168.76,198.75) ; R560.1 115.94,44.29 v1(115.42,43.76) ; v1(128.88,16.64) 128.88,23.22 126.92,25.17 126.92,30.33 128.83,32.23 128.83,36.09 127.91,37.01 v1(127.91,37.47) ; v1(130.53,38.3) 130.35,38.3 123.85,44.81 v1(123.85,45.09)
  TOP w0.305: v5(136.36,161.75) CPU1.D34 ; v5(139.11,163.55) 139.13,163.55 139.13,163.58 139.1,163.58 CPU1.B36 ; v5(128.67,155.35) CPU1.M28 ; v5(130.5,155.35) CPU1.M30 ; v5(138.19,163.58) CPU1.C36 ; 134.53,161.75 CPU1.D32 ; v5(125.02,155.35) CPU1.M24 ; v5(136.36,163.58) CPU1.C34 ; 134.53,158.09 CPU1.H32 ; 134.53,163.58 CPU1.C32 ; v5(126.85,155.35) CPU1.M26 ; v5(138.19,161.75) CPU1.D36 ; v5(127.76,158.09) CPU1.J27
  TOP w0.381: CPU1.F32 134.53,159.92 CPU1.G32
  BOTTOM w0.254: v1(127.91,37.47) 129.31,38.86 129.97,38.86 v1(130.53,38.3) ; 165.6,177.8 167.54,179.74 167.54,196.24 168.76,197.46 v1(168.76,198.75) ; v1(123.85,45.09) 121.67,45.09 120.52,43.94 115.6,43.94 v1(115.42,43.76) ; v1(189.59,72.14) 188.95,71.5 188.95,58.77 189.79,57.94 190.35,57.94 193.27,55.02 193.27,45.41 192.69,44.83 188.99,44.83 186.03,41.87 186.03,23.04 170.48,7.49 162.69,7.49 162.38,7.19 138.96,7.19 138.4,7.75 138.4,11.18 132.94,16.64 v1(128.88,16.64)
  vias: v1(121.49,152.81) v1(121.49,151.76) v1(121.49,150.32) v1(121.49,148.97) v1(121.46,146.28) v1(121.49,145.08) v1(121.49,143.56) v1(121.49,142.32) v1(122.02,186.82) v1(122.33,147.7) v1(123.19,148.95) v1(123.19,146.25) v1(123.93,180.72) v1(124.43,188.85) v1(124.56,186.82) v1(125.07,185.17) v1(125.32,180.09) v1(125.45,178.56) v1(125.83,153.03) v1(125.83,152.15) v1(125.83,151.38) v1(125.83,150.24) v1(125.83,145.8) v1(125.83,144.91) v1(125.83,144.15) v1(125.83,143.38) v1(125.83,142.62) v1(126.85,176.78) v1(127.41,147.78) v1(127.99,185.17) v1(128.75,173.36) v1(128.75,171.45) v1(128.75,169.55) v1(128.75,167.51) v1(130.15,175.39) v1(130.53,179.32) v1(131.8,180.59) v1(131.8,178.05) v1(132.99,175.49) v1(132.99,173.46) v1(133.07,179.32) v1(135.92,175.49) v1(135.92,173.46) v1(138.15,179.32) v1(138.79,175.44) v1(138.79,173.41) v1(139.42,180.72) v1(139.42,178.18) v1(140.69,179.32) v1(140.82,168.78) v1(140.82,167.89) v1(141.66,175.49) v1(141.66,173.46) v1(141.83,169.67) v1(142.6,185.29) v1(142.72,170.69) v1(143.56,171.45) v1(144.4,172.16) v1(145.14,184.78) v1(145.64,173.61) v1(146.28,186.06) v1(146.66,179.7) v1(146.66,174.62) v1(157.33,169.29) v1(157.35,166.75) v1(158.6,168.66) v1(158.62,167.49) v1(158.62,166.24) v1(164.31,170.56) v1(164.57,176.78) v1(165.58,171.83) v1(165.58,169.29) v1(166.09,176.4) v1(166.85,177.8) v1(166.85,170.56) v1(166.85,167.64) v1(171.04,167.77) v1(171.17,170.31) v1(172.31,169.29) v1(173.71,168.15) v1(173.84,170.31)
+VDIMM: length 453.7
  TOP w0.152: U43.6 79.95,15.72 80.16,15.93
  TOP w0.254: R742.1 80.78,13.84 80.3,14.33 v1(80.24,14.33) 80.11,14.2 78.94,14.2 78.54,13.79 77.8,13.79 77.17,14.43 75.06,14.43 74.63,14 74.63,13.03 73.76,12.17 v1(73.76,7.01) ; v1(168.33,79.91) 168.73,80.31 C427.1 R388.1 ; v1(12.9,54.97) 12.55,55.32 RJ4.3 ; v1(158.34,76.07) 158.17,75.9 v1(156.44,75.9) ; v1(103.53,49.28) 104.01,48.79 104.01,45.44 104.27,45.19 105.64,45.19 106.4,45.95 112.73,45.95 113.57,45.11 116.51,45.11 R561.1 118.24,45.21 122.53,45.21 128.88,38.86 128.88,37.67 129.47,37.08 131.17,37.08 131.93,36.32 131.93,33.02 131.29,32.38 130.2,32.38 127.91,30.1 127.91,25.48 129.92,23.47 129.92,13.13 128.57,11.79 120.93,11.79 120.45,11.3 120.45,9.07 v1(120.6,8.92) ; v1(103.5,79.22) 101.83,79.22 101.32,79.73 99.72,79.73 99.45,80.01 C423.1 ; v1(80.16,16.38) 80.16,15.93
  TOP w0.305: v5(118.97,132.49) CPU1.AU15 ; v5(126.82,128.36) 126.76,128.42 CPU1.AY23
  TOP w0.356: DIMM2.189 106.84,92.26 105.58,91 R374.1 ; R375.1 C414.1 v1(161.36,89.82) ; v5(125.36,132.49) 124.93,132.92 CPU1.AT21 ; C411.1 119.84,91.51 DIMM2.176 ; DIMM2.60 115.9,98.24 115.9,99.03 116.38,99.52 C392.1 115.26,100.11 C393.1 ; DIMM2.170 125.84,91.96 125.45,91.57 C413.1 ; v5(118.07,129.74) CPU1.AW14 ; v5(118.07,131.57) CPU1.AU13 ; v3(128.12,130.66) 128.13,130.66 CPU1.AW25 ; v5(127.24,132.49) CPU1.AU23 ; CPU1.AY18 122.19,128.94 122.02,128.78 v5(122.02,128.4) ; v1(98.11,90.77) C403.1 C404.1 ; C416.1 95.76,90.77 C402.1 97.13,90.77 DIMM2.197 ; DIMM2.173 123.93,91.4 C412.1 ; CPU1.AY12 116.7,128.73 v5(116.62,128.65) ; CPU1.AU19 123.13,132.03 v5(123.58,132.49) ; v5(120.36,128.5) CPU1.AY16 ; C405.1 101.84,90.91 DIMM2.194 ; CPU1.AV11 115.51,131.11 v5(115.16,130.76) ; v5(124.93,130.48) CPU1.AV21 ; v5(121.73,130.66) CPU1.AV17 ; CPU1.AW10 112.9,131.11 v5(113.36,131.57) ; DIMM2.191 104.32,92.48 103.1,91.26 C406.1 ; DIMM2.54 121.84,100.13 C391.1 ; C407.1 v1(104.5,91.57) ; v5(121.76,132.49) CPU1.AT18
  TOP w0.381: C420.1 103.45,81.12 104.62,82.3 DIMM1.191 ; C410.1 117.96,91.69 117.17,92.48 DIMM2.179 116.81,92.46 C409.1 ; DIMM1.189 106.84,81.5 C421.1 ; R428.2 144.63,63.47 143.74,62.59 v1(143.54,62.59) 141.68,62.59 140.74,63.53 134.19,63.53 124.73,72.99 124.73,76.48
  TOP w0.508: R299.2 114.25,132.84 113.36,131.95 v5(113.36,131.57) ; R403.2 R410.2 152.22,68.8 C471.2 153.1,68.58 C466.2 154.48,69.85 155.14,69.19 v1(155.14,67.97) ; C423.1 99.14,80.55 99.14,82 DIMM1.197 98.32,81.77 C422.1
  BOTTOM w0.254: v1(103.5,79.22) 103.53,79.25 110.21,79.25 114,75.46 114,70.15 111.33,67.49 111.33,63.07 108.97,60.71 101.78,60.71 100.38,59.31 100.38,52.43 v1(103.53,49.28) ; v1(120.6,8.92) 120.42,8.74 114.53,8.74 113,10.26 106.78,10.26 104.62,8.1 102.67,8.1 99.8,5.23 82.14,5.23 80.72,6.65 74.12,6.65 v1(73.76,7.01) 73.46,7.01 72.97,6.53 56.57,6.53 55.78,7.32 55.75,7.34 52.63,7.34 44.09,15.88 40.64,15.88 39.42,17.09 33.12,17.09 30.25,14.22 25.18,14.22 23.96,15.44 19.48,15.44 16.46,18.47 16.46,21.41 15.49,22.38 14.15,22.38 12.88,23.65 12.88,27.38 11.99,28.27 11.99,54.05 v1(12.9,54.97) ; v1(168.33,79.91) 164.82,76.4 158.67,76.4 v1(158.34,76.07) ; v1(156.44,75.9) 156.13,75.9 155.7,75.46 155.7,71.88 156.49,71.09 156.49,69.32 v1(155.14,67.97) ; v1(80.24,14.33) 80.24,16.31 v1(80.16,16.38)
  BOTTOM w0.381: v1(143.54,62.59) 144.53,61.59 151.74,61.59 153.52,63.37 153.52,66.34 v1(155.14,67.97)
  vias: v1(113.94,81.18) v1(115.11,81.18) v1(116.08,81.18) v1(117.04,81.18) v1(118.14,81.2) v1(119.02,81.2) v1(120.12,81.18) v1(121.01,81.18) v1(125.78,79.3) v1(125.78,77.98) v1(125.78,76.61) v1(126.97,76.45) v1(127.2,79.25) v1(129.24,79.35) v1(130.3,78.18)
+VGA_VCC: length 40.2
  TOP w0.254: v1(172.24,230.63) 172.24,229.95 172.59,229.59 v1(172.59,227.23) 172.58,227.24 U6.5 ; v1(168,227.03) 167.78,227.24 U5.5 166.05,227.24 165.63,227.66 165.63,230.58 v1(165.76,230.71) ; U1.5 173.51,233.48 v1(173.89,233.86)
  TOP w0.381: C1.1 166.44,233.93 166.78,233.93 v1(167.39,233.32)
  TOP w0.406: v1(176.28,233.17) 176.48,233.38 U2.5
  BOTTOM w0.254: SR5.1 172.17,230.56 v1(172.24,230.63) ; SC8.1 173.26,227.23 v1(172.59,227.23) 172.39,227.03 v1(168,227.03) 167.23,227.03 SC7.1 ; v1(165.76,230.71) 166.37,230.71 166.9,231.24 166.9,232.84 v1(167.39,233.32) 168.58,234.52 169.92,234.52 SR1.1 171.39,233.05 172.38,233.05 SC1.1 173.58,233.55 v1(173.89,233.86)
  BOTTOM w0.305: 176.31,233.14 176.31,233.13 175.69,232.51 175.69,232.13 174.57,231.01 173.46,231.01 173.1,230.66 172.26,230.66 v1(172.24,230.63)
  BOTTOM w0.406: SC3.1 176.31,233.14 v1(176.28,233.17)
  vias: v1(165.35,235.64) v1(166.12,235.64)
-ACTIVE_P: length 7.8
  TOP w0.254: R126.1 78.77,214.57 D8.N 79.84,214.49 C105.1 80.49,214.85 80.49,218.13 USB2_LAN.13
-LINK_1G: length 13
  TOP w0.254: USB2_LAN.12 71.18,219.03 68.17,216.03 68.17,213.67 C119.1 67.67,213.11 D10.N 67.59,211.39 R150.1 66.42,211.42 R133.1
-LINK_100: length 13.6
  TOP w0.254: R132.1 65.02,211.42 R149.1 63.8,211.39 D9.N C118.1 64.36,213.77 64.36,214.83 68.56,219.03 USB2_LAN.11
A20GATE: length 8.4
  TOP w0.102: R696.1 104.91,27.18 105.94,27.18 v1(106.35,27.58) 106.58,27.58 107.8,28.8 110.82,28.8 110.99,28.97 U38.22
ACPRESENT: length 32.6
  TOP w0.089: 57.99,39.05 57.99,39.5 58.31,39.82 58.31,42.06 58.13,42.24 58.13,42.48 57.84,42.77 57.84,43.65 57.74,43.75 57.74,43.95 57.53,44.16 PCH1.BB15
  TOP w0.102: R685.1 44.49,28.17 46.57,28.17 47.69,27.05 48.82,27.05 50.96,24.91 53.89,24.91 57.35,28.37 v2(57.35,32.21) 57.35,33.17 57.99,33.81 57.99,39.05
AG1_PHASE_R: length 1.7
  TOP w0.635: R239.1 115.2,190.72 C220.2
AG2_PHASE_R: length 1.6
  TOP w0.635: R240.1 132.85,190.72 C221.2
AG3_PHASE_R: length 1.6
  TOP w0.635: C239.2 179.65,180.05 R264.1
ANTI_POP_L: length 41
  TOP w0.254: R160.2 41.15,208.08 41.15,207.37 40.82,207.04 39.8,207.04 37.95,208.89 v1(37.03,208.89) ; CODEC.47 12.94,215.3 12.47,214.83 12.47,213.69 13.56,212.6 13.56,208.2 v1(14.2,207.57)
  BOTTOM w0.254: v1(14.2,207.57) v2(14.86,206.91) 15.29,206.48 24.66,206.48 25.37,207.19 35.86,207.19 37.03,208.36 v1(37.03,208.89)
ATX_PSON_L: length 492.2
  TOP w0.102: v1(126.39,35.05) 126.77,34.67 126.77,33.35 124.46,31.04 124.46,26.75 123.98,26.26 ; U38.34 116.98,31.44 117.14,31.27 117.14,28.47 117.78,27.84 118.47,27.84 119.01,27.31 122.83,27.31 R694.1 123.37,26.87 123.98,26.26 ; v1(125.43,16.74) 125.65,16.97 125.65,22.71 123.98,24.38 123.98,26.26 ; R295.2 8.71,144.34 4.46,144.34 v1(3.76,145.03) ; v1(129.64,38.2) 129.64,38.56 122.68,45.52 113.64,45.52 112.88,46.28 105.39,46.28 QN25.1 ; ATX_POWER.16 165.38,38.98 165.38,34.49 163.57,32.68 QN26.1 162.44,31.18 C598.1 161.57,30.63 161.57,29.21 161.85,28.93 162.66,28.93 162.92,28.68 162.92,27.84 162.76,27.69 162.76,7.11 v1(162.97,6.91) ; D25.1 v1(188.89,43.94)
  BOTTOM w0.102: v1(188.89,43.94) 186.36,41.41 186.36,37.11 186.39,37.08 186.39,22.5 170.79,6.91 v1(162.97,6.91) 162.71,6.65 138.86,6.65 137.77,7.75 137.77,11.05 132.79,16.03 128.78,16.03 127.56,17.25 125.93,17.25 v1(125.43,16.74) 125.43,11.71 126.67,10.46 126.67,6.07 123.7,3.1 120.37,3.1 119.66,3.81 117.14,3.81 115.01,1.68 46.84,1.68 43.36,5.16 43.36,7.39 43.71,7.75 43.71,9.45 43.33,9.83 43.33,10.77 43.03,11.07 42.62,11.07 42.19,10.64 39.78,10.64 38.58,11.84 33.76,11.84 30.89,8.97 10.01,8.97 9.68,8.64 4.32,8.64 3.17,9.78 3.17,16.1 2.64,16.64 2.64,17.93 1.19,19.38 1.19,140.16 3.76,142.72 v1(3.76,145.03) ; v1(126.39,35.05) 126.97,35.05 129.64,37.72 v1(129.64,38.2)
ATX_PSON_R: length 2.8
  TOP w0.102: R295.1 10.36,146.13 QN11.1 v1(8.73,146.37)
ATX_PWRGD: length 529.1
  TOP w0.102: C531.1 143.36,50.55 141.33,48.51 141.33,44.27 144.83,40.77 144.83,37.23 ATX_POWER.8 ; C531.1 R505.2 ; C531.1 142.61,51.34 v1(142.29,51.66) ; R347.1 v1(196.36,113.44) ; v1(54.28,126.44) 56.03,126.44 R312.1 ; v1(186.28,44.45) 187.68,43.05 189.84,43.05 190.79,44 D25.2 ; v1(102.95,34.24) 102.69,33.99 101.66,33.99 R621.1 ; v1(76.89,78.64) 76.2,77.95 74.88,77.95 74.4,78.44 61.26,78.44 60.6,77.77 56.08,77.77 53.39,80.47 53.39,83.95 47.37,89.97 47.37,93.17 46.08,94.46 46.08,99.31 48.62,101.85 50.16,101.85 51.05,102.74 52.58,102.74 56.62,106.78 56.62,113.84 54.25,116.2 v1(54.25,117.04) ; R518.2 v1(134.59,51.77) ; R438.1 158.06,62.36 v1(158.06,61.75) 158.22,61.59 166.98,61.59 169.76,58.82 169.76,45.96 165.64,41.84 165.64,34.35 164.21,32.92 v1(164.21,9.63) ; v1(102.82,59.72) v1(102.82,63.68)
  BOTTOM w0.102: v1(54.25,117.04) 54,117.3 54,126.16 v1(54.28,126.44) ; v1(196.36,113.44) 196.85,112.95 196.85,92.66 185.75,81.56 185.75,75.54 187.66,73.63 187.66,45.82 v1(186.28,44.45) 185.2,43.37 185.2,23.4 171.75,9.96 164.54,9.96 v1(164.21,9.63) 155.24,9.63 153.52,11.35 151.87,11.35 149.79,9.27 142.14,9.27 132.99,18.41 125.3,18.41 124.43,19.28 124.43,25.25 125.53,26.34 125.53,27.79 121.77,31.55 117.4,31.55 115.93,33.02 104.55,33.02 103.81,33.76 103.43,33.76 v1(102.95,34.24) ; v1(76.89,78.64) 77.7,79.45 93.42,79.45 94.18,78.69 102.57,78.69 104.19,77.06 104.19,65.05 v1(102.82,63.68) ; v1(102.82,59.72) 103.07,59.97 109.02,59.97 111.99,62.94 111.99,66.98 114.01,69 134.53,69 142.98,60.55 154.36,60.55 155.55,61.75 v1(158.06,61.75) 158.06,59.51 156.97,58.42 154.74,58.42 148.34,52.02 143.15,52.02 142.8,51.66 v1(142.29,51.66) 141.15,52.81 135.64,52.81 v1(134.59,51.77)
ATX_PWRGD_R: length 6.4
  TOP w0.102: U38.6 106.44,35.04 105.82,34.42 C586.1 104.67,35.1 v2(103.28,35.1) 102.86,35.1 R621.2
AUGND: length 63.6
  TOP w0.254: CODEC.42 14.85,217.8 15.39,218.34 v1(15.39,220.07) ; CODEC.26 v1(20.39,220.33)
  TOP w0.406: Q2.E2 15.7,238.2 v1(15.7,238.48) ; Q4.E2 21.72,238.37 v1(21.72,238.89) ; v1(15.75,234.75) 15.75,235.05 16.3,235.6 Q3.E1 ; v1(18.31,238.58) 18.31,238.27 Q3.E2 ; v1(24.59,237.82) 24.37,237.6 Q5.E2 ; C154.1 10.23,206.98 v1(10.59,207.34) ; Q4.E1 19.05,235.01 v1(19.05,234.7) ; Q1.E2 12.44,237.78 v1(13.06,238.4) ; Q2.E1 13.8,235.32 13.18,234.7 v1(13.18,234.54) ; Q1.E1 v1(10.46,235.6) ; Q5.E1 22.44,235.32 v1(21.69,234.57)
  TOP w0.508: C138.1 10.59,207.79 v1(10.59,207.34) ; C64.2 v1(10.29,220.27) ; v1(15.09,227.74) 15.49,227.33 C23.2 v1(17.42,228.27) ; v1(23.42,229.13) 23.42,228.78 C17.2 24.99,227.2 v1(25.3,227.2) ; R231.2 5.74,193.93 v1(5.49,194.18) 5.49,194.66 6.12,195.29 D14.3 ; R43.2 38.93,223.53 v1(39.01,223.44) 39.22,223.24 C48.2 ; v1(11.25,207.01) 11.36,207.12 R171.2 ; C65.2 58.78,219.66 58.09,218.97 v1(58.09,218.62) 58.78,217.93 R102.2 ; C124.1 10.1,213.32 9.45,213.97 v1(8.94,213.97) ; v1(9.88,218.19) 10.24,217.83 R106.1 ; D11.3 v1(10.46,210.45) ; v1(44.4,216.94) R118.1 v1(46.1,217.07) ; C199.1 v1(3.88,196.22) ; v1(4.34,193.68) 4.22,193.55 4.22,192.89 4.06,192.74 R236.1 3.53,193.12 v1(3.53,193.65) ; D5.3 v1(56.54,219.46) ; C66.2 v1(50.29,218.92) 50.29,218.14 R104.2 ; v1(25.63,209.93) 25.5,209.8 R161.1 24.61,210.34 v1(24.16,210.79) ; C26.2 23.32,225.22 v1(23.32,224.61) ; C67.2 v1(54.31,218.92) 54.31,218.19 R105.2 ; v1(45.54,218.69) 45.41,218.56 R107.2 ; D3.3 v1(40.71,223.88) ; C24.2 20.27,227.74 v1(19.51,227.74) ; v1(48.06,219.38) D6.3 ; v1(4.65,194.41) 4.64,194.42 R228.2 ; C25.2 v1(18.01,227.33) ; C68.2 46.36,219.07 v1(46.56,219.07) ; R136.2 v1(8.1,212.72) ; C32.2 v1(41.33,224.79) 41.19,224.92 R38.2 ; C200.1 8.36,196.82 v1(7.77,196.24) ; C50.2 v1(9.02,221.8)
BATLOW_L: length 7.9
  TOP w0.089: PCH1.BD13 56.41,43.26 56.54,43.13 56.54,41.66 56.87,41.33 56.87,39.22 56.36,38.71 55.8,38.71 54.58,37.49 54.58,36.96
  TOP w0.102: 54.58,36.96 R606.1
BCLK: length 6.1
  TOP w0.102: CODEC.6 17.89,212.26 18.26,211.89 18.59,211.89 18.9,211.58 C129.1 18.34,210.48 18.34,208.81 R169.2
BG2_PHASE_R: length 1.6
  TOP w0.635: R298.1 179.77,144.62 C317.2
BG3_PHASE_R: length 1.6
  TOP w0.635: C197.2 101.61,199.99 R217.1
BOOT2B_C: length 3.1
  TOP w0.635: C328.2 188.7,141.64 188.7,139.95 R301.2
BOOT3A_C: length 3.1
  TOP w0.635: C243.2 187.3,177.07 187.3,175.39 187.68,175.01
BT_DIS_L: length 41.9
  TOP w0.102: M2_1.54 33.19,119.7 32.23,118.75 30.28,118.75 v1(30.23,118.69) ; v1(24.76,105.97) 24.54,106.2 19.81,106.2 19.51,105.89 v1(19.02,105.89) ; v1(25.88,99.39) 26.21,99.72 29.64,99.72 R368.2 R369.2
  BOTTOM w0.102: v1(19.02,105.89) 19.46,105.89 20.04,106.48 20.04,107.47 29.92,117.35 29.92,118.39 v1(30.23,118.69) ; v1(25.88,99.39) 25.73,99.54 25.73,103.25 v2(25.96,103.48) 25.96,104.78 v1(24.76,105.97)
BT_DIS_L_R: length 172.1
  TOP w0.089: PCH1.BC23 61.19,43.71 61.19,43.19 60.77,42.77 60.77,41.87 61.39,41.25 61.39,39.12 60.88,38.61 60.88,38.38 v3(60.38,37.87)
  TOP w0.102: R368.1 30.71,92.58 28.85,90.73 28.85,74.07 20.12,65.33 20.12,48.84 14.53,43.26 13.64,43.26 v1(13.41,43.48) ; v1(60.4,26.26) 60.32,26.19 60.32,20.98 57.12,17.78 57.12,15.16 56.57,14.6 55.65,14.6 55.14,14.1 54.05,14.1 53.7,13.74 52.91,13.74 52.3,13.13 52.3,12.2 51.83,11.73 51.39,11.73 48.93,9.27 45.38,9.27 45.15,9.5 43.15,9.5 38.99,13.67 33.27,13.67 30.61,11 30.15,11 v1(26.37,14.78)
  BOTTOM w0.089: v3(60.38,37.87) 60.48,37.77 60.48,36.98 v2(60.45,36.96) 60.45,36.53 60.25,36.32
  BOTTOM w0.102: v1(26.37,14.78) 25.05,14.78 24.08,15.75 19.66,15.75 16.76,18.64 16.76,21.56 15.65,22.68 14.27,22.68 13.21,23.75 13.21,29.16 14,29.95 14,34.28 13.16,35.12 13.16,41.91 13.69,42.44 13.69,43.21 v1(13.41,43.48) ; v1(60.4,26.26) 59.84,26.82 59.84,29.39 59.21,30.02 59.21,30.81 59.89,31.5 59.89,33.96 60.25,34.32 60.25,36.32
BUFCLK_IN: length 2.6
  TOP w0.102: U37.1 96.38,44.64 96.6,44.86 97.26,44.86 97.66,45.26 R544.2
BUFCLK_OUT2: length 8.3
  TOP w0.102: U37.5 94.61,42.17 C562.1 93.64,41.2 91.9,41.2 91.26,41.83 v2(91.26,42.75) 91.26,42.98 92.41,44.13 R552.1
BUFCLK_OUT3: length 2.6
  TOP w0.102: U37.3 95,43.17 94.75,42.93 C557.1 94.13,43.02 R553.1
BV1N: length 72.3
  TOP w0.203: R207.2 169.42,200.78 v1(169.42,201.5) 169.42,202.29 R187.1 ; SP7.2 178.64,152.18 178.64,152.61 176.34,154.91 170.34,154.91 169.77,155.48 169.77,156.36 v1(169.52,156.62)
  BOTTOM w0.203: v1(169.42,201.5) 169.67,201.24 169.67,197.09 168.27,195.7 168.27,180.12 170.03,178.37 170.03,172.97 171.23,171.78 175.9,171.78 177.44,170.23 177.44,167.77 176.78,167.11 171.76,167.11 169.82,165.17 169.82,156.92 v1(169.52,156.62)
BV2N: length 104.4
  TOP w0.203: v1(174.52,201.52) 174.52,202.16 R190.1 R189.2 ; SP9.2 v1(178.22,133.29)
  BOTTOM w0.203: v1(178.22,133.29) 178.64,133.71 178.64,134.16 175.51,137.29 172.02,137.29 171.09,138.21 171.09,142.76 169.54,144.31 169.54,148.48 170.57,149.5 172.62,149.5 172.87,149.25 176.4,149.25 178,150.85 178,152.86 176.33,154.53 172.65,154.53 171.22,155.97 171.22,164.46 172.75,165.99 177.37,165.99 178.59,167.21 178.59,170.87 176.56,172.89 171.69,172.89 171.15,173.44 171.15,178.83 169.39,180.58 169.39,195.22 174.8,200.63 174.8,201.24 v1(174.52,201.52)
CA_REF_RC: length 1.4
  TOP w0.254: C426.2 112.97,80.65 R387.1
CFG0: length 60.4
  TOP w0.102: v5(117.7,159.91) 117.26,159.46 CPU1.H15 ; R259.1 72,180.8 74.78,180.8 75.56,181.58 v1(75.59,181.58)
  BOTTOM w0.102: v1(75.59,181.58) 76.1,181.58 79.95,177.73 99.3,177.73 102.65,174.37 109.98,174.37 115.04,169.32 115.04,165.78 116.74,164.08 116.74,162.51 117.24,162 117.24,160.36 v5(117.7,159.91)
CFG1: length 57.9
  TOP w0.102: R260.1 74.32,181.36 75.95,182.98 v1(76.78,182.98) ; v5(117.68,161.73) CPU1.F15
  BOTTOM w0.102: v1(76.78,182.98) 76.78,182.7 v2(77.22,182.27) 77.98,181.51 77.98,180.24 80.13,178.09 99.44,178.09 102.8,174.73 110.13,174.73 116.56,168.3 116.56,165.96 116.94,165.58 116.94,162.59 117.68,161.85 v5(117.68,161.73)
CFG2: length 59.6
  TOP w0.102: R258.1 75.48,184 77.52,184 v1(78.54,182.98) ; v5(118.62,161.75) CPU1.F16
  BOTTOM w0.102: v5(118.62,161.75) 117.42,162.94 117.42,165.07 117.73,165.38 117.73,168.13 110.43,175.44 103.25,175.44 99.87,178.82 80.9,178.82 v2(80.06,179.65) 79.4,180.31 79.4,182.12 v1(78.54,182.98)
CFG3: length 62.4
  TOP w0.102: v5(118.62,159.92) CPU1.H16 ; v1(76.17,184.78) 75.74,184.78 74.6,183.64 R256.1
  BOTTOM w0.102: v1(76.17,184.78) 77.47,184.78 79.65,182.6 79.65,180.9 81.51,179.04 99.99,179.04 103.37,175.67 110.7,175.67 117.98,168.38 117.98,165.28 117.68,164.97 117.68,162.98 118.47,162.18 118.8,162.18 119.05,161.93 119.05,160.35 v5(118.62,159.92)
CFG4: length 66.4
  TOP w0.102: R250.1 74.85,185.93 76.2,187.27 v1(78.59,187.27) ; v5(121.34,161.77) CPU1.F19
  BOTTOM w0.102: v5(121.34,161.77) 121.79,162.22 121.79,163.06 121.26,163.59 121.26,167.19 v2(121.46,167.39) 121.46,169.04 112.01,178.49 104.7,178.49 100.96,182.22 94.79,182.22 87.21,189.8 81.11,189.8 79.6,188.29 v2(79.6,187.68) 79.2,187.27 v1(78.59,187.27)
CFG5: length 71.6
  TOP w0.102: v5(120.43,159.94) CPU1.H18 ; R244.1 72.03,186.49 74.96,186.49 76.4,187.93 v1(76.86,187.93)
  BOTTOM w0.102: v1(76.86,187.93) v2(77.7,187.93) 78.87,187.93 81.09,190.15 87.37,190.15 95.07,182.45 101.07,182.45 104.77,178.74 112.09,178.74 122.17,168.66 122.17,163.68 122.12,163.63 122.12,161.94 121.5,161.32 121.25,161.32 120.93,160.99 120.93,160.44 v5(120.43,159.94)
CFG6: length 70.4
  TOP w0.102: CPU1.G21 122.75,160.38 v5(123.22,160.84) ; v1(77.5,192.46) 76.1,191.06 73.62,191.06 R237.1
  BOTTOM w0.102: v5(123.22,160.84) 123.22,160.99 123.98,161.75 123.98,168.53 112.57,179.93 105.31,179.93 101.6,183.64 96.46,183.64 88.16,191.95 79.1,191.95 78.56,192.48 77.52,192.48 v1(77.5,192.46)
CFG7: length 73.5
  TOP w0.102: v1(79.88,192.66) 79.2,193.34 73.59,193.34 R235.1 ; CPU1.H20 v5(121.36,159)
  BOTTOM w0.102: v5(121.36,159) 121.84,159.49 122.53,159.49 123.65,160.61 123.65,161.04 124.18,161.57 124.18,168.68 112.66,180.19 105.39,180.19 101.71,183.87 96.74,183.87 88.3,192.31 80.23,192.31 v1(79.88,192.66)
CFG8: length 62.8
  TOP w0.102: v5(118.62,160.83) CPU1.G16 ; v1(77.65,182.98) 77.01,183.62 76,183.62 74.29,181.91 72.03,181.91 R257.1
  BOTTOM w0.102: v1(77.65,182.98) 78.71,181.91 v2(78.71,181.31) 78.71,180.01 80.28,178.44 99.59,178.44 102.95,175.08 110.28,175.08 116.79,168.57 116.79,166.12 117.14,165.76 117.14,162.88 118.16,161.86 118.16,161.29 v5(118.62,160.83)
CFG9: length 63.9
  TOP w0.102: v5(118.6,162.66) 118.16,162.22 CPU1.E16 ; v1(77.93,185.34) 77.85,185.42 75.79,185.42 74.57,184.2 72.42,184.2 71.86,183.64 R255.1 R251.1
  BOTTOM w0.102: v5(118.6,162.66) 117.98,163.28 117.98,164.97 118.26,165.25 118.26,168.61 110.85,176.02 103.52,176.02 100.14,179.4 81.76,179.4 80.01,181.15 80.01,183.26 v2(79.4,183.87) v1(77.93,185.34)
CFG10: length 61.9
  TOP w0.102: CPU1.F17 119.1,161.29 v5(119.56,161.75) ; v1(77.42,186.06) 75.92,186.06 74.65,184.78 R252.1
  BOTTOM w0.102: v1(77.42,186.06) 78.61,186.06 80.47,184.2 80.47,183.21 83.21,180.47 100.74,180.47 104.09,177.11 111.27,177.11 119.96,168.42 119.96,162.43 119.56,162.02 v5(119.56,161.75)
CFG11: length 67.7
  TOP w0.102: v5(119.53,159.92) CPU1.H17 ; v1(79.91,185.88) 79.15,186.64 75.92,186.64 74.63,185.34 72.03,185.34 R249.1
  BOTTOM w0.102: v5(119.53,159.92) 119.99,160.38 119.99,162.17 120.19,162.38 120.19,168.7 111.55,177.34 104.23,177.34 100.88,180.7 83.31,180.7 80.82,183.18 80.82,184.96 v1(79.91,185.88)
CFG12: length 69.1
  TOP w0.102: CPU1.G20 121.85,160.38 v5(122.29,159.94) ; v1(75.59,188.93) 75.16,189.36 R242.1
  BOTTOM w0.102: v5(122.29,159.94) 122.29,160.06 122.76,160.53 122.76,163.4 122.78,163.42 122.78,169.06 112.39,179.45 105.08,179.45 101.37,183.16 95.91,183.16 87.83,191.24 79.91,191.24 78.89,190.22 76.89,190.22 v1(75.59,188.93)
CFG13: length 67.7
  TOP w0.102: v1(76.76,189.38) 75.59,188.21 R243.1 ; v5(122.27,160.83) CPU1.F20
  BOTTOM w0.102: v5(122.27,160.83) 122.53,161.09 122.53,163.46 122.58,163.51 122.58,168.94 112.32,179.2 105,179.2 101.27,182.93 95.61,182.93 87.66,190.88 79.93,190.88 78.71,189.66 v2(77.8,189.66) 77.04,189.66 v1(76.76,189.38)
CFG14: length 68.7
  TOP w0.102: v1(77.22,191.21) 76.83,191.21 75.54,189.92 73.62,189.92 R238.1 ; CPU1.F21 122.73,161.32 v5(123.19,161.77)
  BOTTOM w0.102: v1(77.22,191.21) v2(78.71,191.21) 78.94,191.21 79.32,191.59 88.01,191.59 96.19,183.41 101.47,183.41 105.18,179.7 112.47,179.7 123.11,169.06 123.11,163.6 123.62,163.1 123.62,162.2 v5(123.19,161.77)
CFG15: length 68.8
  TOP w0.102: CPU1.H19 v5(121.38,159.94) ; v1(77.22,188.75) 76.86,188.75 75.18,187.07 R245.1
  BOTTOM w0.102: v5(121.38,159.94) 121.82,160.38 121.82,161.01 122.33,161.52 122.33,163.54 122.38,163.59 122.38,168.81 112.22,178.97 104.9,178.97 101.17,182.7 95.33,182.7 87.52,190.51 80.45,190.51 v2(79.71,189.76) 78.69,188.75 v1(77.22,188.75)
CFG_RCOMP: length 4.3
  TOP w0.203: CPU1.M11 114.15,155.24 114.43,155.24
  TOP w0.305: 114.43,155.24 116.38,153.29 R287.1
CHARGE: length 8.2
  TOP w0.203: R134.2 174.97,213.33 172.67,213.33 172.19,212.85 C123.2 171.71,212.6 170.03,212.6 169.43,212 U19.9
CLK0_24M: length 13.5
  TOP w0.089: 59.18,37.95 59.18,41.41 58.88,41.71 58.88,42.3 58.7,42.48 58.7,42.93 58.46,43.17 58.46,43.49 58.69,43.71 PCH1.BC17
  TOP w0.102: 59.18,37.95 59.18,36.98 C584.1 59.23,36.68 60.02,35.89 60.02,34.97 59.26,34.21 59.26,31.93 59.11,31.78 R662.1
CLK1_24M: length 29.8
  TOP w0.089: v3(59.34,46.66) PCH1.AV19
  TOP w0.102: v1(57.15,27) 57.15,26.39 56.57,25.81 56.36,25.81 54.43,23.87 C622.1 R722.1 R721.1
  BOTTOM w0.089: 57.28,36.32 58.05,37.09 58.05,40.29 58.78,41.02 58.78,43.05 59.24,43.52 59.24,44.46 58.93,44.77 58.93,46.25 v3(59.34,46.66)
  BOTTOM w0.102: v1(57.15,27) 57.15,29.9 v2(56.79,30.25) 56.59,30.45 56.59,33.68 56.08,34.19 56.08,35.13 57.28,36.32
CLK_REQ1_M.2_WLAN_L: length 208.7
  TOP w0.089: v3(62.76,45.9) PCH1.AW24
  TOP w0.102: R355.1 R357.2 32.09,108.55 28.59,105.05 23.42,105.05 21.86,103.49 21.86,100.34 21.31,99.8 21.31,89.73 27.86,83.18 27.86,73.94 19.51,65.58 19.51,49.5 14.27,44.27 v1(13.51,44.27) ; v1(65.13,28.24) 65.68,27.69 65.68,27.3 65.74,27.25 65.74,27.22 65.79,27.17 65.79,22.22 62.36,18.8 62.36,17.86 60.22,15.72 60.22,12.93 59.13,11.84 56.51,11.84 54,9.32 54,8.81 53.52,8.33 52.37,8.33 51.92,8.79 50.9,8.79 50.14,8.03 43.64,8.03 38.86,12.8 33.44,12.8 28.63,7.99 28.63,7.98 28.45,7.8 28.45,7.77 28.04,7.37 27.03,7.37 25.93,8.46 25.93,12.27 24.68,13.53 24.68,15.41 v1(25.25,15.98)
  BOTTOM w0.089: v3(62.76,45.9) 62.31,45.45 62.31,43.36 v2(62.53,43.13) 62.74,42.93 62.74,40.54 63.98,39.29 63.98,36.32
  BOTTOM w0.102: v1(25.25,15.98) 24.72,15.98 24.34,16.36 20.04,16.36 17.42,18.97 17.42,21.92 16,23.34 14.58,23.34 13.87,24.05 13.87,28.95 14.66,29.74 14.66,44.09 14.48,44.27 v1(13.51,44.27) ; 63.98,36.32 63.98,34.39 65.53,32.84 65.53,31.39 65.18,31.04 65.18,28.3 v1(65.13,28.24)
CLK_REQ1_WLAN_S: length 3.8
  TOP w0.102: v2(33.81,110.26) 33.36,110.71 R355.2 32.87,111.02 33.44,111.59 M2_1.53
CLKREQ3_SSD_L: length 89.7
  TOP w0.089: v3(62.15,38.04) 62.37,38.25 62.37,43.17 PCH1.BD25
  TOP w0.102: v1(80.09,12.73) 80.09,12.34 83.57,8.86 95.96,8.86 96.62,9.53 97.33,9.53 97.71,9.14 101.85,9.14 105.33,12.62 105.33,13.36 v1(103.76,14.94) ; v1(62.46,26.8) 62.2,26.54 62.2,22.45 57.63,17.88 v1(57.63,17.3)
  BOTTOM w0.089: v3(62.15,38.04) 61.93,37.81 61.93,36.32
  BOTTOM w0.102: v1(103.76,14.94) 103.78,14.94 v2(104.37,15.52) 105.13,16.28 SR34.2 106.11,17.27 SR33.1 ; v1(57.63,17.3) 67.97,17.3 68.98,16.28 72.67,16.28 73.25,16.87 75.87,16.87 76.66,16.08 76.66,14.91 78.74,12.83 79.98,12.83 v1(80.09,12.73) ; v1(62.46,26.8) 62.61,26.95 62.61,33.45 61.93,34.14 61.93,36.32
CLKREQ3_SSD_S: length 2.5
  TOP w0.102: M2_2.52 108.08,17.67 v1(108.31,17.45)
  BOTTOM w0.102: v1(108.31,17.45) 108.13,17.27 SR33.2
CLKRUN_L: length 22.9
  TOP w0.089: PCH1.AW22 60.77,45.55 v3(60.43,45.77)
  TOP w0.102: R695.1 61.77,27.84 61.19,28.42 59.13,28.42 v1(58.98,28.58)
  BOTTOM w0.089: 59.69,36.32 59.69,39.88 60.91,41.1 60.91,43.15 61.11,43.36 61.11,44.33 60.93,44.51 60.83,44.62 60.83,45.38 v3(60.43,45.77)
  BOTTOM w0.102: v1(58.98,28.58) 58.75,28.8 58.75,31.04 59.44,31.72 59.44,34.39 59.79,34.75 59.79,36.22 59.69,36.32
COM1_RI_L: length 386.9
  TOP w0.102: v1(51.59,186.89) 51.59,187.68 52.07,188.16 52.07,190.07 51.28,190.86 R233.2 ; v1(12.67,44.86) 12.75,44.78 14.22,44.78 19.28,49.83 19.28,65.68 27.64,74.04 27.64,83.08 21.06,89.66 21.06,98.88 20.32,99.62 20.32,100.43 21.08,101.19 21.08,102.84 18.54,105.38 18.54,106.5 25.04,113 25.04,115.16 25.98,116.1 25.98,117.17 v1(25.78,117.37) ; R572.1 104.57,40.93 106.25,39.24 109.65,39.24 109.79,39.11 U38.62 109.79,37.3 113.56,33.53 113.56,32.44 v1(113.36,32.23) ; v1(121.81,10.44) 122.76,10.44 v1(122.83,10.36) ; v1(51.92,177.8) 50.9,176.78 40.69,176.78 40,176.1 37.11,176.1 35.1,178.1 32.44,178.1 30.81,179.73 v1(30.51,179.73)
  BOTTOM w0.102: v1(25.78,117.37) 25.78,119.48 24.51,120.75 24.51,123.44 28.75,127.69 28.75,140.06 27.94,140.87 27.94,176.56 28.42,177.04 28.42,177.04 30.51,179.13 v1(30.51,179.73) ; v1(51.92,177.8) 51.59,178.13 v1(51.59,186.89) ; v1(12.67,44.86) 14.35,44.86 14.88,44.32 14.88,29.64 14.1,28.85 14.1,24.16 14.63,23.62 16.05,23.62 17.68,22 17.68,19.05 20.14,16.59 25.86,16.59 27.53,14.91 29.9,14.91 32.82,17.83 32.82,18.41 33.78,19.38 37.41,19.38 38.99,17.81 39.7,17.81 40.94,16.56 44.4,16.56 52.86,8.1 56.03,8.1 56.92,7.21 71.5,7.21 72.34,8.05 73.96,8.05 74.68,7.34 81.08,7.34 82.5,5.92 99.31,5.92 102.29,8.89 104.34,8.89 106.4,10.95 113.61,10.95 114.58,9.98 121.35,9.98 v1(121.81,10.44) ; v1(122.83,10.36) 122.91,10.44 v2(122.91,11.2) 122.91,27.76 123.06,27.91 123.06,28.91 121.36,30.61 113.18,30.61 112.83,30.96 112.83,31.7 v1(113.36,32.23)
CPU_24MCLK_N: length 158.8
  TOP w0.089: v5(112.22,158.09) CPU1.J9
  TOP w0.102: v1(47.5,71.88) 47.14,72.24 47.05,72.24 46.48,71.67 46.48,68.1 47.65,66.93 47.65,63.25 48.65,62.25 50.14,62.25 50.4,62 50.57,62 PCH1.F1
  BOTTOM w0.089: 110.83,151.47 110.83,151.48 110.83,155.61 110.31,156.13 110.31,157.24 110.87,157.8 111.92,157.8 v5(112.22,158.09)
  BOTTOM w0.102: v1(47.5,71.88) 47.18,72.19 47.16,72.18 45.99,72.18 44.65,73.51 44.65,79.52 41.88,82.29 41.88,98.15 43.56,99.83 43.56,108.21 50.52,115.17 50.52,128.07 63.17,140.72 63.17,142.96 65.52,145.31 78.05,145.31 85.87,153.14 90.76,153.14 92.51,151.38 106.39,151.38 106.8,150.98 110.33,150.98 110.83,151.47
CPU_24MCLK_P: length 158.9
  TOP w0.089: v5(112.22,157.18) CPU1.K9
  TOP w0.102: v1(47.5,72.79) 47.14,72.44 46.96,72.44 46.28,71.75 46.28,68.01 47.45,66.84 47.45,63.17 48.57,62.05 50.06,62.05 50.31,61.8 50.57,61.8 PCH1.G1
  BOTTOM w0.089: v5(112.22,157.18) 111.78,157.61 110.95,157.61 110.5,157.16 110.5,156.21 111.02,155.69 111.02,151.38
  BOTTOM w0.102: 111.02,151.38 110.41,150.77 106.71,150.77 106.31,151.18 92.43,151.18 90.68,152.93 85.95,152.93 78.13,145.11 65.61,145.11 63.37,142.88 63.37,140.64 50.72,127.99 50.72,115.09 43.76,108.13 43.76,99.75 42.09,98.07 42.09,82.37 44.86,79.6 44.86,73.59 46.07,72.38 47.08,72.38 v1(47.5,72.79)
CPU_BCLK_N: length 145.1
  TOP w0.102: PCH1.H2 50,61.11 49.8,61.32 48.36,61.32 46.61,63.07 46.61,66.65 45.57,67.69 45.57,72.21 47.12,73.76 47.73,73.76 47.98,74.02 47.98,74.24 v1(47.75,74.47) ; CPU1.W4 v5(107.64,149.86)
  BOTTOM w0.102: v5(107.64,149.86) 107.2,149.42 105.11,149.42 104.26,148.56 102.26,148.56 101.73,149.1 91.42,149.1 89.64,150.88 86.86,150.88 78.86,142.88 67.28,142.88 51.94,127.54 51.94,114.63 44.98,107.67 44.98,99.24 43.36,97.61 43.36,82.8 48.03,78.12 48.03,77.55 v2(47.7,77.22) 48.03,76.89 48.03,74.75 v1(47.75,74.47)
